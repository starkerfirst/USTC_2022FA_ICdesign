$ Spice netlist generated by v2lvs
$ v2013.2_18.13    Thu May 16 11:29:55 PDT 2013

.SUBCKT systolic_array clk_p rstn_p en_p p_shift_in<7> p_shift_in<6>
+ p_shift_in<5> p_shift_in<4> p_shift_in<3> p_shift_in<2> p_shift_in<1>
+ p_shift_in<0> p_shift_out<7> p_shift_out<6> p_shift_out<5> p_shift_out<4>
+ p_shift_out<3> p_shift_out<2> p_shift_out<1> p_shift_out<0> ack_p VDD VSS
Xicc_route_opt1490 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<46>
+ Z=n4849
Xicc_route_opt1489 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<171>
+ Z=n4848
Xicc_route_opt1488 BUFFD12BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<74>
+ Z=n4847
Xicc_route_opt1487 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<61>
+ Z=n4846
Xicc_route_opt1486 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<66>
+ Z=n4845
Xicc_route_opt1485 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_output_row_1<0>
+ Z=n4844
Xicc_route_opt1484 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<141>
+ Z=n4843
Xicc_route_opt1483 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4842
+ I=SA_core_connect<113>
Xicc_route_opt1482 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<28>
+ Z=n4841
Xicc_route_opt1481 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<12>
+ Z=n4840
Xicc_route_opt1480 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_output_row_1<6>
+ Z=n4839
Xicc_route_opt1479 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4838
+ I=SA_core_connect<122>
Xicc_route_opt1478 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<37>
+ Z=n4837
Xicc_route_opt1477 CKBD12BWP7T $PINS VSS=VSS I=SA_core_connect<112> VDD=VDD
+ Z=n4836
Xicc_route_opt1476 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<94>
+ Z=n4835
Xicc_route_opt1475 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<79>
+ Z=n4834
Xicc_route_opt1474 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<41>
+ Z=n4833
Xicc_route_opt1473 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<85>
+ Z=n4832
Xicc_route_opt1472 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4831
+ I=SA_core_connect<72>
Xicc_route_opt1471 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4830 I=n3088
Xicc_route_opt1470 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4829 I=n3583
Xicc_route_opt1469 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_output_row_1<4>
+ Z=n4828
Xicc_route_opt1468 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4827 I=n1525
Xicc_route_opt1467 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4826 I=n1082
Xicc_route_opt1466 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4825
+ I=SA_core_connect<48>
Xicc_route_opt1465 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<45>
+ Z=n4824
Xicc_route_opt1464 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4823 I=n1408
Xicc_route_opt1463 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4822
+ I=SA_core_connect<137>
Xicc_route_opt1462 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4821
+ I=SA_core_connect<129>
Xicc_route_opt1461 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4820
+ I=SA_core_connect<88>
Xicc_route_opt1460 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4819 I=n1097
Xicc_route_opt1459 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<36>
+ Z=n4818
Xicc_route_opt1458 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<6>
+ Z=n4817
Xicc_route_opt1457 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4816 I=n3087
Xicc_route_opt1456 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4815
+ I=SA_core_pe_3_3_N14
Xicc_route_opt1455 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<10>
+ Z=n4814
Xicc_route_opt1454 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3803 Z=n4813
Xicc_route_opt1453 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<70>
+ Z=n4812
Xicc_route_opt1452 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<172>
+ Z=n4811
Xicc_route_opt1451 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4810
+ I=SA_core_connect<161>
Xicc_route_opt1450 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4809 I=n1286
Xicc_route_opt1449 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4808 I=n703
Xicc_route_opt1448 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4807 I=n2118
Xicc_route_opt1447 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4806 I=n3110
Xicc_route_opt1446 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4805 I=n3638
Xicc_place1598 BUFFD12BWP7T $PINS VSS=VSS I=SA_ctrl_state_load_row<0> VDD=VDD
+ Z=n4653
XU1592 CKND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3144 ZN=n4462 A2=n3143
XU2737 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_1<2> ZN=n3884
XU3807 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n3270 A1=n3278 ZN=n978 A2=n3281
XU3150 INVD1BWP7T $PINS ZN=n2717 VSS=VSS VDD=VDD I=SA_core_shift_wire<17>
Xicc_place1673 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4728 I=n4725
Xicc_place1582 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<24> ZN=n4637
Xicc_place1599 INVD3BWP7T $PINS VDD=VDD VSS=VSS ZN=n4654 I=n4653
XU1464 ND2D0BWP7T $PINS VSS=VSS VDD=VDD A1=SA_ctrl_state_load_id<0> ZN=n3113
+ A2=SA_ctrl_state_load_id<1>
XU1870 INVD1P5BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<34> ZN=n3802
Xicc_place1579 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_1<0> ZN=n4634
XU1740 MOAI22D0BWP7T $PINS A2=n1354 A1=n3086 ZN=SA_core_pe_3_2_N17 B1=n3084
+ VSS=VSS B2=SA_core_shift_wire<87> VDD=VDD
XU1629 ND2D4BWP7T $PINS A1=n4729 ZN=n3086 A2=n4770 VDD=VDD VSS=VSS
XU2522 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4608 ZN=n2104 A2=n4690
XU2372 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<99> ZN=n3851
XU3019 AOI21D2BWP7T $PINS VSS=VSS A2=n3769 VDD=VDD A1=n2593 B=n2605 ZN=n2599
XU1503 INVD1BWP7T $PINS ZN=n3769 VSS=VSS VDD=VDD I=SA_core_output_row_0<1>
XU4409 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4710 ZN=n3628 A2=n4717
XU3043 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2642 A1=n4642 A3=n3768 A2=n3748
Xicc_place1587 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4641 ZN=n4642
XU3059 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2660 A1=n4642 A3=n3767 A2=n4577
Xicc_place1522 INVD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4577 I=n4576
XU1681 INVD1BWP7T $PINS ZN=n3000 VSS=VSS VDD=VDD I=SA_core_shift_wire<92>
XU1433 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3088 A1=n3091
+ A3=SA_ctrl_state_compute_out<1> A2=n4708
XU1437 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=ack A1=SA_ctrl_state_compute_out<1>
+ ZN=n2589 A2=SA_ctrl_state_compute_out<0>
XU2630 INVD1BWP7T $PINS ZN=n3880 VSS=VSS VDD=VDD I=SA_col_1<6>
XU4226 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3575 A2=n3516
Xicc_place1450 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4505 I=shift_in<3>
XU2501 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_2<2> ZN=n3864
XU1521 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1134 A1=n4644 A3=n1118 A2=n4640
Xicc_place1589 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_0<1> ZN=n4644
XU1876 CKND1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<26> ZN=n3803
XU3536 AOI221D2BWP7T $PINS B2=n3119 A1=n4780 A2=n4472 ZN=n3121 B1=n4654 VDD=VDD
+ C=n3129 VSS=VSS
XU3262 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N20
+ A2=n3848
Xicc_place1691 INVD6BWP7T $PINS VDD=VDD VSS=VSS ZN=n4746 I=n3084
Xicc_place1653 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=ack ZN=n4708
XU2149 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<56> A1=n4599
+ ZN=n1744 A3=SA_core_shift_wire<66>
XU2547 INVD4BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<1> ZN=n3871
Xicc_place1481 CKND2BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_1<1> ZN=n4536
XU3010 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<16> A1=SA_col_3<0>
+ ZN=n2594 A3=SA_core_output_row_0<0>
XU3011 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2594 A1=n2587 ZN=n2591
+ A2=SA_core_output_row_0<0>
XU4038 ND2D2BWP7T $PINS A1=n4345 ZN=n3411 VDD=VDD A2=n4714 VSS=VSS
XU4335 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n3638 A3=n4462 A2=n4651
+ A1=n4653
XU4213 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4706 A1=n3514 ZN=n3567 A2=n4462
XU1616 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N18 A2=n4679
Xicc_place1647 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n4702 I=n4693
Xicc_place1645 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4700 I=n4693
XU2645 INVD1BWP7T $PINS ZN=n2223 VSS=VSS VDD=VDD I=SA_core_shift_wire<41>
XU2011 CKND1BWP7T $PINS ZN=n1616 VSS=VSS VDD=VDD I=n1610
Xicc_place1674 CKND4BWP7T $PINS VSS=VSS VDD=VDD ZN=n4729 I=n4728
Xicc_place1583 CKND1BWP7T $PINS VDD=VDD VSS=VSS I=n4822 ZN=n4638
XU2128 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4847 ZN=n3833
XU2231 MOAI22D1BWP7T $PINS A2=n1846 A1=n4470 ZN=SA_core_pe_2_2_N17 B1=n1606
+ VSS=VSS B2=n4551 VDD=VDD
Xicc_place1643 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4698 I=n4693
XU4228 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3577 A2=n3516
Xicc_place1449 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4504 I=shift_in<4>
XU4145 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3689 ZN=n3475 A2=n4721
Xicc_place1666 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD I=n4777 Z=n4721
XU2371 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N18 A2=n4636
Xicc_place1635 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<40> ZN=n4690
XU2506 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<40> A1=n4609
+ ZN=n2101 A3=n4844
Xicc_place1554 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<168>
+ Z=n4609
Xicc_place1540 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4594 ZN=n4595
Xicc_place1592 INVD2BWP7T $PINS VSS=VSS VDD=VDD ZN=n4647 I=SA_core_connect<0>
XU1900 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<25> ZN=n3806
XU4716 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4267 A3=n4462 A2=n4654
+ A1=n4650
Xicc_place1595 CKBD10BWP7T $PINS VSS=VSS VDD=VDD Z=n4650
+ I=SA_ctrl_state_load_row<1>
Xicc_place1676 INVD5BWP7T $PINS VSS=VSS VDD=VDD I=n4730 ZN=n4731
Xicc_place1671 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4726 I=n4725
XU3115 MOAI22D1BWP7T $PINS A2=n2711 A1=n4743 ZN=SA_core_pe_0_3_N17 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<23> VDD=VDD
Xicc_place1616 INVD3BWP7T $PINS VDD=VDD VSS=VSS I=n4842 ZN=n4671
XU2520 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<2> ZN=n3870
XU4318 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4718 ZN=n3583 A2=n4356
Xicc_place1663 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4718 I=n3722
XU2900 AOI21D2BWP7T $PINS VSS=VSS A2=n2464 VDD=VDD A1=n2465 B=n2481 ZN=n2470
XU2899 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2481 A1=n4687 A3=n2465 A2=n4643
XU2897 INVD1BWP7T $PINS ZN=n2465 VSS=VSS VDD=VDD I=SA_core_shift_wire<25>
XU2290 MOAI22D0BWP7T $PINS A2=n4470 A1=n1869 ZN=SA_core_pe_2_1_N13 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<51> VDD=VDD
Xicc_place1464 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4518 ZN=n4519
XU3534 OAI22D0BWP7T $PINS B1=n4651 A2=n3118 ZN=n1082 A1=n3129 VDD=VDD B2=n3128
+ VSS=VSS
XU2392 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1989 A1=n4686 A3=n1973 A2=n4636
Xicc_place1631 CKND1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<105> ZN=n4686
XU2390 INVD1BWP7T $PINS ZN=n1973 VSS=VSS VDD=VDD I=SA_core_shift_wire<49>
XU1432 INVD2BWP7T $PINS ZN=n3091 VSS=VSS VDD=VDD I=SA_ctrl_state_compute_out<0>
XU3328 MOAI22D1BWP7T $PINS A2=n2886 A1=n4743 ZN=SA_core_pe_0_1_N15 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<5> VDD=VDD
XU1861 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N18
+ A2=n4669
XU3718 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3281 A2=n4779
Xicc_place1531 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4779 I=n3225
Xicc_place1628 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4682 ZN=n4683
XU2611 MOAI22D1BWP7T $PINS A2=n2217 A1=n4745 ZN=SA_core_pe_1_3_N17 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<47> VDD=VDD
XU2058 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1712 A1=n4689 A3=n1652 A2=n1672
Xicc_place1634 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4688 ZN=n4689
XU3282 MOAI22D1BWP7T $PINS A2=n2843 A1=n4743 ZN=SA_core_pe_0_1_N11 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<1> VDD=VDD
XU3047 MOAI22D1BWP7T $PINS A2=n4743 A1=n2612 ZN=SA_core_pe_0_3_N13 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<19> VDD=VDD
Xicc_place1688 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=n4743 I=n4742
XU3046 XOR3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2617 A1=n2618 A3=n2616 Z=n2612
XU1752 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N23
+ A2=n1417
XU3018 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2605 A1=n4642 A3=n3769 A2=n4691
XU1450 AOI22D2BWP7T $PINS B1=SA_core_output_row_0<4> A2=SA_core_output_row_3<4>
+ ZN=n1100 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
Xicc_place1682 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4770 ZN=n4737
Xicc_place1681 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4736 I=n2589
Xicc_place1633 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<177>
+ Z=n4688
Xicc_place1576 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<144> ZN=n4631
XU1977 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n3086 A2=n1599 A1=n1600
+ ZN=SA_core_pe_3_0_N17 C=n1598
XU3726 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3289 A2=n3225
Xicc_place1640 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4695 I=n4693
Xicc_place1495 INVD2BWP7T $PINS VSS=VSS VDD=VDD ZN=n4550 I=n4549
XU2357 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N26 A2=n4619
Xicc_place1577 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_2<1> ZN=n4632
XU1919 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1539 A1=n4671 A3=n1512 A2=n3869
Xicc_place1687 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4742 I=n2917
XU1455 AOI22D1BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<6> ZN=n1105 A1=n4816
+ VDD=VDD B2=n4839 VSS=VSS
Xicc_place1580 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_col_0<0> ZN=n4635
XU2362 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<1> ZN=n3849
XU1664 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1287 A1=n4629 A3=n2982 A2=n4569
XU3247 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N28 A2=n3884
XU1691 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1340 A1=n4629 A3=n4523 A2=n3829
Xicc_place1574 CKND1BWP7T $PINS VSS=VSS I=n4810 VDD=VDD ZN=n4629
Xicc_place1575 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<120> ZN=n4630
XU2530 MOAI22D1BWP7T $PINS A2=n4745 A1=n2109 ZN=SA_core_pe_1_3_N12 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<42> VDD=VDD
Xicc_place1690 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=n4745 I=n2538
XU3266 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N22 A2=n4527
Xicc_place1637 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_col_1<1> ZN=n4692
XU1452 AOI22D1BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<5> ZN=n1103 A1=n4816
+ VDD=VDD B2=SA_core_output_row_1<5> VSS=VSS
XU2886 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_1_0_N22
+ A2=n3856
XU3833 AOI22D1BWP7T $PINS B1=n4695 A2=n3295 ZN=n3292 A1=SA_col_3<6> VDD=VDD
+ B2=SA_B_3_shift_reg_5__6_ VSS=VSS
XU1438 AOI22D1BWP7T $PINS B1=SA_core_output_row_0<0> A2=SA_core_output_row_3<0>
+ ZN=n1092 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU2359 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N27 A2=n4686
XU2243 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N31
+ A2=n4584
XU2109 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<49> ZN=n3825
XU1516 AOI21D1BWP7T $PINS A2=ack A1=n4736 ZN=n2917 VDD=VDD B=n4726 VSS=VSS
XU1426 NR2XD4BWP7T $PINS VSS=VSS VDD=VDD A1=n4656 ZN=ack A2=n4522
XU1878 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1485 A2=n1476 A1=n1477
+ ZN=SA_core_pe_3_0_N10 C=n3086
XU3822 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n3280 A1=n3281 ZN=n971 A2=n3295
XU2563 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2203 A1=n4646 A3=n2143 A2=n2163
Xicc_place1612 INVD1P5BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<153>
+ ZN=n4667
XU1877 NR3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1485 A1=n3816 A3=n1477 A2=n4669
XU1989 INVD1P5BWP7T $PINS VDD=VDD VSS=VSS I=n4836 ZN=n3816
XU1434 AOI22D1BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<0> ZN=n1093 A1=n4816
+ VDD=VDD B2=n4844 VSS=VSS
XU2555 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2168 A1=n4646 A3=n2133 A2=n4615
Xicc_place1560 INVD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4615 I=n4614
Xicc_place1591 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4645 ZN=n4646
XU1859 IOA22D1BWP7T $PINS A2=n4834 A1=n3084 ZN=SA_core_pe_3_1_N17 B1=n3086
+ VSS=VSS B2=n1475 VDD=VDD
XU1634 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n4770 ZN=n3084 A2=n4730
XU3152 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2728 A1=n4633 A3=n2717 A2=n4579
Xicc_place1578 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_2<1> ZN=n4633
XU1865 NR2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N20 A2=n3870
XU2009 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1621 A1=n4689 A3=n1608 A2=n4648
XU2008 INVD1BWP7T $PINS ZN=n1608 VSS=VSS VDD=VDD I=SA_core_output_row_2<1>
XU4722 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4271 A3=n4677 A2=n4772
+ A1=SA_ctrl_state_load_id<0>
XU3830 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n3288 A1=n3289 ZN=n967 A2=n3295
XU3829 AOI22D1BWP7T $PINS B1=n4695 A2=n3295 ZN=n3288 A1=SA_col_3<4> VDD=VDD
+ B2=SA_B_3_shift_reg_5__4_ VSS=VSS
XU3820 ND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n4719 ZN=n3295 A2=n4734
XU4719 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4272 A3=n4677 A2=n4772
+ A1=n4780
XU2639 CKAN2D0BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_2_N24 A2=n4729
+ A1=n4611
XU1930 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1557 A1=n4671 A3=n4524 A2=n3868
XU1881 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1496 A1=n4671 A3=n1479 A2=n4669
XU1481 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<123> ZN=n3757
XU3142 INVD1BWP7T $PINS ZN=n2770 VSS=VSS VDD=VDD I=SA_core_connect<13>
XU2041 MAOI222D2BWP7T $PINS ZN=n4227 VDD=VDD VSS=VSS A=n1616 C=n1614 B=n1615
XU2513 INVD2BWP7T $PINS ZN=n2099 VSS=VSS VDD=VDD I=SA_core_output_row_1<1>
XU3319 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2912 B=n2943 A2=n2878
+ A1=SA_core_shift_wire<13>
XU2121 INVD2BWP7T $PINS ZN=n3829 VSS=VSS VDD=VDD I=SA_core_connect<84>
XU1768 INVD1BWP7T $PINS ZN=n1479 VSS=VSS VDD=VDD I=SA_core_shift_wire<73>
XU3173 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2735 B=n2761 A2=n2730
+ A1=SA_core_shift_wire<19>
XU1526 AOI21D1BWP7T $PINS VSS=VSS A2=n1120 VDD=VDD A1=n4778 B=n1119
+ ZN=SA_core_pe_0_0_N11
XU2515 AOI21D1BWP7T $PINS VSS=VSS A2=n2099 VDD=VDD A1=n2100 B=n2112 ZN=n2106
XU2924 AOI22D1BWP7T $PINS B1=n2482 A2=n2489 ZN=n2485 A1=n2483 VDD=VDD B2=n2490
+ VSS=VSS
Xicc_place1562 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4616 ZN=n4617
XU2010 AOI21D2BWP7T $PINS VSS=VSS A1=n1609 VDD=VDD B=n1621 ZN=n1615 A2=n1608
XU2395 IAO22D2BWP7T $PINS A2=n1979 ZN=n1975 A1=n1977 B2=n1977 VDD=VDD B1=n1979
+ VSS=VSS
XU3068 AOI21D1BWP7T $PINS VSS=VSS A2=n2635 VDD=VDD A1=n3766 B=n2697 ZN=n2667
XU2035 AOI21D1BWP7T $PINS VSS=VSS A2=n1623 VDD=VDD A1=n1624 B=n1659 ZN=n1629
XU2211 MAOI222D2BWP7T $PINS ZN=n4211 VDD=VDD VSS=VSS A=n2847 C=n2845 B=n4418
XU3419 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3036 A1=n4628 A3=n3840 A2=n4561
XU3029 MAOI222D2BWP7T $PINS ZN=n2610 C=n2598 B=n2599 VDD=VDD A=n2600 VSS=VSS
XU4995 AOI21D1BWP7T $PINS VSS=VSS A2=n2716 VDD=VDD A1=n2717 B=n4425 ZN=n4450
XU2564 AOI21D1BWP7T $PINS VSS=VSS A2=n2142 VDD=VDD A1=n2143 B=n2203 ZN=n2173
XU1675 INVD2BWP7T $PINS ZN=n3788 VSS=VSS VDD=VDD I=SA_core_connect<187>
XU1931 AOI21D1BWP7T $PINS VSS=VSS A2=n1518 VDD=VDD A1=n4524 B=n1557 ZN=n1549
XU3420 AOI21D1BWP7T $PINS VSS=VSS A2=n2997 VDD=VDD A1=n3840 B=n3036 ZN=n3015
XU2668 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2241 B=n2268 A2=n2236
+ A1=SA_core_shift_wire<43>
XU1891 MAOI222D2BWP7T $PINS ZN=n1489 C=n1483 B=n1484 VDD=VDD A=n1485 VSS=VSS
XU2248 INVD1BWP7T $PINS ZN=n3841 VSS=VSS VDD=VDD I=SA_core_shift_wire<84>
XU1799 INVD1BWP7T $PINS ZN=n1425 VSS=VSS VDD=VDD I=SA_core_connect<140>
XU1787 AOI21D1BWP7T $PINS VSS=VSS A2=n1372 VDD=VDD A1=n3843 B=n4823 ZN=n1378
XU2682 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2267 B=n2288 A2=n2252
+ A1=SA_core_shift_wire<44>
XU1882 AOI21D2BWP7T $PINS VSS=VSS A2=n1478 VDD=VDD A1=n1479 B=n1496 ZN=n1484
XU1755 INVD2BWP7T $PINS ZN=n1477 VSS=VSS VDD=VDD I=SA_core_shift_wire<72>
XU2443 IAO22D2BWP7T $PINS A2=n2022 ZN=n2020 A1=n2021 B2=n2021 VDD=VDD B1=n2022
+ VSS=VSS
XU3028 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2606 A1=SA_core_output_row_0<2>
+ ZN=n2611 A2=n2597
XU2294 INVD1BWP7T $PINS ZN=n3845 VSS=VSS VDD=VDD I=SA_core_connect<5>
XU2019 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1622 A1=SA_core_output_row_2<2>
+ ZN=n1627 A2=n1613
XU1920 AOI21D1BWP7T $PINS VSS=VSS A2=n1511 VDD=VDD A1=n1512 B=n1539 ZN=n1524
XU2655 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2235 A1=SA_core_shift_wire<42>
+ ZN=n2239 A2=n2226
XU1572 MAOI22D1BWP7T $PINS A2=n1165 ZN=n1164 A1=n1166 B2=n1166 VDD=VDD B1=n1165
+ VSS=VSS
XU2540 AOI21D1BWP7T $PINS VSS=VSS A2=n2114 VDD=VDD A1=n2115 B=n2150 ZN=n2120
XU2759 INVD1BWP7T $PINS ZN=n2404 VSS=VSS VDD=VDD I=n4841
XU2496 INVD1P5BWP7T $PINS ZN=n2169 VSS=VSS VDD=VDD I=SA_core_connect<173>
XU2051 AOI21D1BWP7T $PINS VSS=VSS A2=n1641 VDD=VDD A1=n1642 B=n1677 ZN=n1658
XU1884 IAO22D2BWP7T $PINS A2=n1485 ZN=n1481 A1=n1483 B2=n1483 VDD=VDD B1=n1485
+ VSS=VSS
XSA_B_3_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1008
+ Q=SA_B_3_shift_reg_1__2_ VDD=VDD
XSA_B_3_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1009
+ Q=SA_B_3_shift_reg_1__1_ VDD=VDD
XSA_B_3_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1010
+ Q=SA_B_3_shift_reg_1__0_ VDD=VDD
XSA_B_3_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1011
+ Q=SA_B_3_shift_reg_0__7_ VDD=VDD
XSA_B_3_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1012
+ Q=SA_B_3_shift_reg_0__6_ VDD=VDD
XSA_B_3_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1013
+ Q=SA_B_3_shift_reg_0__5_ VDD=VDD
XSA_B_3_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1014
+ Q=SA_B_3_shift_reg_0__4_ VDD=VDD
XSA_B_3_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1015
+ Q=SA_B_3_shift_reg_0__3_ VDD=VDD
XSA_B_3_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1016
+ Q=SA_B_3_shift_reg_0__2_ VDD=VDD
XSA_B_3_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1017
+ Q=SA_B_3_shift_reg_0__1_ VDD=VDD
XSA_B_3_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1018
+ Q=SA_B_3_shift_reg_0__0_ VDD=VDD
XSA_A_0_shift_reg_reg_6__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1020
+ Q=SA_row_0<7> VDD=VDD
XSA_A_0_shift_reg_reg_6__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1021
+ Q=SA_row_0<6> VDD=VDD
XSA_A_0_shift_reg_reg_6__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1022
+ Q=SA_row_0<5> VDD=VDD
XSA_A_0_shift_reg_reg_6__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1023
+ Q=SA_row_0<4> VDD=VDD
XSA_A_0_shift_reg_reg_6__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1024
+ Q=SA_row_0<3> VDD=VDD
XSA_A_0_shift_reg_reg_6__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1026
+ Q=SA_row_0<1> VDD=VDD
XSA_A_0_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1075
+ Q=SA_A_0_shift_reg_5__7_ VDD=VDD
XSA_A_0_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1028
+ Q=SA_A_0_shift_reg_5__6_ VDD=VDD
XSA_A_0_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1029
+ Q=SA_A_0_shift_reg_5__5_ VDD=VDD
XSA_A_0_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1030
+ Q=SA_A_0_shift_reg_5__4_ VDD=VDD
XSA_A_0_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1031
+ Q=SA_A_0_shift_reg_5__3_ VDD=VDD
XSA_A_0_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1032
+ Q=SA_A_0_shift_reg_5__2_ VDD=VDD
XSA_A_0_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1033
+ Q=SA_A_0_shift_reg_5__1_ VDD=VDD
XSA_A_0_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1034
+ Q=SA_A_0_shift_reg_5__0_ VDD=VDD
XSA_A_0_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1035
+ Q=SA_A_0_shift_reg_4__7_ VDD=VDD
XSA_A_0_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1036
+ Q=SA_A_0_shift_reg_4__6_ VDD=VDD
XSA_A_0_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1037
+ Q=SA_A_0_shift_reg_4__5_ VDD=VDD
XSA_A_0_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1038
+ Q=SA_A_0_shift_reg_4__4_ VDD=VDD
XSA_A_0_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1039
+ Q=SA_A_0_shift_reg_4__3_ VDD=VDD
XSA_A_0_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1040
+ Q=SA_A_0_shift_reg_4__2_ VDD=VDD
XSA_A_0_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1041
+ Q=SA_A_0_shift_reg_4__1_ VDD=VDD
XSA_A_0_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1042
+ Q=SA_A_0_shift_reg_4__0_ VDD=VDD
XSA_A_0_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1043
+ Q=SA_A_0_shift_reg_3__7_ VDD=VDD
XSA_A_0_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1044
+ Q=SA_A_0_shift_reg_3__6_ VDD=VDD
XSA_A_0_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1045
+ Q=SA_A_0_shift_reg_3__5_ VDD=VDD
XSA_A_0_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1046
+ Q=SA_A_0_shift_reg_3__4_ VDD=VDD
XSA_A_0_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1047
+ Q=SA_A_0_shift_reg_3__3_ VDD=VDD
XSA_A_0_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1048
+ Q=SA_A_0_shift_reg_3__2_ VDD=VDD
XSA_A_0_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1049
+ Q=SA_A_0_shift_reg_3__1_ VDD=VDD
XSA_A_0_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1050
+ Q=SA_A_0_shift_reg_3__0_ VDD=VDD
XSA_A_0_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1051
+ Q=SA_A_0_shift_reg_2__7_ VDD=VDD
XSA_A_0_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1052
+ Q=SA_A_0_shift_reg_2__6_ VDD=VDD
XSA_A_0_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1053
+ Q=SA_A_0_shift_reg_2__5_ VDD=VDD
XSA_A_0_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1054
+ Q=SA_A_0_shift_reg_2__4_ VDD=VDD
XSA_A_0_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1055
+ Q=SA_A_0_shift_reg_2__3_ VDD=VDD
XSA_A_0_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1056
+ Q=SA_A_0_shift_reg_2__2_ VDD=VDD
XSA_A_0_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1057
+ Q=SA_A_0_shift_reg_2__1_ VDD=VDD
XSA_A_0_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1058
+ Q=SA_A_0_shift_reg_2__0_ VDD=VDD
XSA_A_0_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1059
+ Q=SA_A_0_shift_reg_1__7_ VDD=VDD
XSA_A_0_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1060
+ Q=SA_A_0_shift_reg_1__6_ VDD=VDD
XSA_A_0_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1061
+ Q=SA_A_0_shift_reg_1__5_ VDD=VDD
XSA_A_0_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1062
+ Q=SA_A_0_shift_reg_1__4_ VDD=VDD
XSA_A_0_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1063
+ Q=SA_A_0_shift_reg_1__3_ VDD=VDD
XSA_A_0_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1064
+ Q=SA_A_0_shift_reg_1__2_ VDD=VDD
XSA_A_0_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1065
+ Q=SA_A_0_shift_reg_1__1_ VDD=VDD
XSA_A_0_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1066
+ Q=SA_A_0_shift_reg_1__0_ VDD=VDD
XSA_A_0_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1067
+ Q=SA_A_0_shift_reg_0__7_ VDD=VDD
XSA_A_0_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1068
+ Q=SA_A_0_shift_reg_0__6_ VDD=VDD
XSA_A_0_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1069
+ Q=SA_A_0_shift_reg_0__5_ VDD=VDD
XSA_A_0_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n1070
+ Q=SA_A_0_shift_reg_0__4_ VDD=VDD
XSA_A_0_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1071
+ Q=SA_A_0_shift_reg_0__3_ VDD=VDD
XSA_A_0_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1072
+ Q=SA_A_0_shift_reg_0__2_ VDD=VDD
XSA_A_0_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1073
+ Q=SA_A_0_shift_reg_0__1_ VDD=VDD
XSA_A_0_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1074
+ Q=SA_A_0_shift_reg_0__0_ VDD=VDD
XSA_ctrl_state_compute_out_counter_reg_0_ DFQD0BWP7T $PINS VSS=VSS
+ CP=clk_G2B4I10 D=n1076 Q=SA_ctrl_state_compute_out_counter<0> VDD=VDD
XSA_ctrl_state_compute_out_counter_reg_1_ DFQD0BWP7T $PINS VSS=VSS
+ CP=clk_G2B4I10 D=n1077 Q=SA_ctrl_state_compute_out_counter<1> VDD=VDD
XSA_ctrl_state_load_AB_reg DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n1079
+ Q=SA_ctrl_state_load_AB VDD=VDD
XSA_ctrl_state_compute_pump_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=n1084 Q=SA_ctrl_state_compute_pump<3> VDD=VDD
XSA_ctrl_state_compute_pump_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=n1085 Q=SA_ctrl_state_compute_pump<2> VDD=VDD
XSA_ctrl_state_compute_pump_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=n1086 Q=SA_ctrl_state_compute_pump<1> VDD=VDD
XSA_ctrl_state_compute_pump_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=n1087 Q=SA_ctrl_state_compute_pump<0> VDD=VDD
XSA_ctrl_state_overall_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n1089
+ Q=SA_ctrl_state_overall<0> VDD=VDD
Xu_pad_data_out_8 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=ack_p
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=ack DS=n628
Xu_pad_data_out_7 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<7>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<7> DS=n628
Xu_pad_data_out_6 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<6>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<6> DS=n628
Xu_pad_data_out_5 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<5>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<5> DS=n628
Xu_pad_data_out_4 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<4>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<4> DS=n628
Xu_pad_data_out_3 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<3>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=n4761 DS=n628
Xu_pad_data_out_2 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<2>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<2> DS=n628
Xu_pad_data_out_1 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<1>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<1> DS=n628
Xu_pad_data_out_0 PDDW0208CDG $PINS PE=SA_ctrl__Logic0_ PAD=p_shift_out<0>
+ OEN=SA_ctrl__Logic0_ IE=SA_ctrl__Logic0_ I=shift_out<0> DS=n628
Xu_pad_data_in_8 PDDW0208CDG $PINS PE=n628 PAD=en_p OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=en
Xu_pad_data_in_7 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<7> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<7>
Xu_pad_data_in_6 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<6> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<6>
Xu_pad_data_in_5 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<5> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<5>
Xu_pad_data_in_4 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<4> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<4>
Xu_pad_data_in_3 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<3> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<3>
Xu_pad_data_in_2 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<2> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<2>
Xu_pad_data_in_1 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<1> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<1>
Xu_pad_data_in_0 PDDW0208CDG $PINS PE=n628 PAD=p_shift_in<0> OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=shift_in<0>
Xu_pad_rst_n PDUW0208SCDG $PINS PE=n628 PAD=rstn_p OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=rstn
Xu_pad_clk PDDW0208SCDG $PINS PE=n628 PAD=clk_p OEN=n628 IE=n628
+ I=SA_ctrl__Logic0_ DS=SA_ctrl__Logic0_ C=clk
XSA_B_1_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n899
+ Q=SA_B_1_shift_reg_0__7_ VDD=VDD
XSA_B_1_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n900
+ Q=SA_B_1_shift_reg_0__6_ VDD=VDD
XSA_B_1_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n901
+ Q=SA_B_1_shift_reg_0__5_ VDD=VDD
XSA_B_1_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n902
+ Q=SA_B_1_shift_reg_0__4_ VDD=VDD
XSA_B_1_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n903
+ Q=SA_B_1_shift_reg_0__3_ VDD=VDD
XSA_B_1_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n904
+ Q=SA_B_1_shift_reg_0__2_ VDD=VDD
XSA_B_1_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n905
+ Q=SA_B_1_shift_reg_0__1_ VDD=VDD
XSA_B_1_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n906
+ Q=SA_B_1_shift_reg_0__0_ VDD=VDD
XSA_B_2_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n963
+ Q=SA_B_2_shift_reg_5__7_ VDD=VDD
XSA_B_2_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n916
+ Q=SA_B_2_shift_reg_5__6_ VDD=VDD
XSA_B_2_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n917
+ Q=SA_B_2_shift_reg_5__5_ VDD=VDD
XSA_B_2_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n918
+ Q=SA_B_2_shift_reg_5__4_ VDD=VDD
XSA_B_2_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n919
+ Q=SA_B_2_shift_reg_5__3_ VDD=VDD
XSA_B_2_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n920
+ Q=SA_B_2_shift_reg_5__2_ VDD=VDD
XSA_B_2_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n921
+ Q=SA_B_2_shift_reg_5__1_ VDD=VDD
XSA_B_2_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n922
+ Q=SA_B_2_shift_reg_5__0_ VDD=VDD
XSA_B_2_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n923
+ Q=SA_B_2_shift_reg_4__7_ VDD=VDD
XSA_B_2_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n924
+ Q=SA_B_2_shift_reg_4__6_ VDD=VDD
XSA_B_2_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n925
+ Q=SA_B_2_shift_reg_4__5_ VDD=VDD
XSA_B_2_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n926
+ Q=SA_B_2_shift_reg_4__4_ VDD=VDD
XSA_B_2_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n927
+ Q=SA_B_2_shift_reg_4__3_ VDD=VDD
XSA_B_2_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n928
+ Q=SA_B_2_shift_reg_4__2_ VDD=VDD
XSA_B_2_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n929
+ Q=SA_B_2_shift_reg_4__1_ VDD=VDD
XSA_B_2_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n930
+ Q=SA_B_2_shift_reg_4__0_ VDD=VDD
XSA_B_2_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n931
+ Q=SA_B_2_shift_reg_3__7_ VDD=VDD
XSA_B_2_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n932
+ Q=SA_B_2_shift_reg_3__6_ VDD=VDD
XSA_B_2_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n933
+ Q=SA_B_2_shift_reg_3__5_ VDD=VDD
XSA_B_2_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n934
+ Q=SA_B_2_shift_reg_3__4_ VDD=VDD
XSA_B_2_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n935
+ Q=SA_B_2_shift_reg_3__3_ VDD=VDD
XSA_B_2_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n936
+ Q=SA_B_2_shift_reg_3__2_ VDD=VDD
XSA_B_2_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n937
+ Q=SA_B_2_shift_reg_3__1_ VDD=VDD
XSA_B_2_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n938
+ Q=SA_B_2_shift_reg_3__0_ VDD=VDD
XSA_B_2_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n939
+ Q=SA_B_2_shift_reg_2__7_ VDD=VDD
XSA_B_2_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n940
+ Q=SA_B_2_shift_reg_2__6_ VDD=VDD
XSA_B_2_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n941
+ Q=SA_B_2_shift_reg_2__5_ VDD=VDD
XSA_B_2_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n942
+ Q=SA_B_2_shift_reg_2__4_ VDD=VDD
XSA_B_2_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n943
+ Q=SA_B_2_shift_reg_2__3_ VDD=VDD
XSA_B_2_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n944
+ Q=SA_B_2_shift_reg_2__2_ VDD=VDD
XSA_B_2_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n945
+ Q=SA_B_2_shift_reg_2__1_ VDD=VDD
XSA_B_2_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n946
+ Q=SA_B_2_shift_reg_2__0_ VDD=VDD
XSA_B_2_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n947
+ Q=SA_B_2_shift_reg_1__7_ VDD=VDD
XSA_B_2_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n948
+ Q=SA_B_2_shift_reg_1__6_ VDD=VDD
XSA_B_2_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n949
+ Q=SA_B_2_shift_reg_1__5_ VDD=VDD
XSA_B_2_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n950
+ Q=SA_B_2_shift_reg_1__4_ VDD=VDD
XSA_B_2_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n951
+ Q=SA_B_2_shift_reg_1__3_ VDD=VDD
XSA_B_2_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n952
+ Q=SA_B_2_shift_reg_1__2_ VDD=VDD
XSA_B_2_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n953
+ Q=SA_B_2_shift_reg_1__1_ VDD=VDD
XSA_B_2_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n954
+ Q=SA_B_2_shift_reg_1__0_ VDD=VDD
XSA_B_2_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n955
+ Q=SA_B_2_shift_reg_0__7_ VDD=VDD
XSA_B_2_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n956
+ Q=SA_B_2_shift_reg_0__6_ VDD=VDD
XSA_B_2_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n957
+ Q=SA_B_2_shift_reg_0__5_ VDD=VDD
XSA_B_2_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n958
+ Q=SA_B_2_shift_reg_0__4_ VDD=VDD
XSA_B_2_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n959
+ Q=SA_B_2_shift_reg_0__3_ VDD=VDD
XSA_B_2_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n960
+ Q=SA_B_2_shift_reg_0__2_ VDD=VDD
XSA_B_2_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n961
+ Q=SA_B_2_shift_reg_0__1_ VDD=VDD
XSA_B_2_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n962
+ Q=SA_B_2_shift_reg_0__0_ VDD=VDD
XSA_B_3_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1019
+ Q=SA_B_3_shift_reg_5__7_ VDD=VDD
XSA_B_3_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n972
+ Q=SA_B_3_shift_reg_5__6_ VDD=VDD
XSA_B_3_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n973
+ Q=SA_B_3_shift_reg_5__5_ VDD=VDD
XSA_B_3_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n974
+ Q=SA_B_3_shift_reg_5__4_ VDD=VDD
XSA_B_3_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n975
+ Q=SA_B_3_shift_reg_5__3_ VDD=VDD
XSA_B_3_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n976
+ Q=SA_B_3_shift_reg_5__2_ VDD=VDD
XSA_B_3_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n977
+ Q=SA_B_3_shift_reg_5__1_ VDD=VDD
XSA_B_3_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n978
+ Q=SA_B_3_shift_reg_5__0_ VDD=VDD
XSA_B_3_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n979
+ Q=SA_B_3_shift_reg_4__7_ VDD=VDD
XSA_B_3_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n980
+ Q=SA_B_3_shift_reg_4__6_ VDD=VDD
XSA_B_3_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n981
+ Q=SA_B_3_shift_reg_4__5_ VDD=VDD
XSA_B_3_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n982
+ Q=SA_B_3_shift_reg_4__4_ VDD=VDD
XSA_B_3_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n983
+ Q=SA_B_3_shift_reg_4__3_ VDD=VDD
XSA_B_3_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n984
+ Q=SA_B_3_shift_reg_4__2_ VDD=VDD
XSA_B_3_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n985
+ Q=SA_B_3_shift_reg_4__1_ VDD=VDD
XSA_B_3_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n986
+ Q=SA_B_3_shift_reg_4__0_ VDD=VDD
XSA_B_3_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n987
+ Q=SA_B_3_shift_reg_3__7_ VDD=VDD
XSA_B_3_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n988
+ Q=SA_B_3_shift_reg_3__6_ VDD=VDD
XSA_B_3_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n989
+ Q=SA_B_3_shift_reg_3__5_ VDD=VDD
XSA_B_3_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n990
+ Q=SA_B_3_shift_reg_3__4_ VDD=VDD
XSA_B_3_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n991
+ Q=SA_B_3_shift_reg_3__3_ VDD=VDD
XSA_B_3_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n992
+ Q=SA_B_3_shift_reg_3__2_ VDD=VDD
XSA_B_3_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n993
+ Q=SA_B_3_shift_reg_3__1_ VDD=VDD
XSA_B_3_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n994
+ Q=SA_B_3_shift_reg_3__0_ VDD=VDD
XSA_B_3_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n995
+ Q=SA_B_3_shift_reg_2__7_ VDD=VDD
XSA_B_3_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n996
+ Q=SA_B_3_shift_reg_2__6_ VDD=VDD
XSA_B_3_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n997
+ Q=SA_B_3_shift_reg_2__5_ VDD=VDD
XSA_B_3_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n998
+ Q=SA_B_3_shift_reg_2__4_ VDD=VDD
XSA_B_3_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n999
+ Q=SA_B_3_shift_reg_2__3_ VDD=VDD
XSA_B_3_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1000
+ Q=SA_B_3_shift_reg_2__2_ VDD=VDD
XSA_B_3_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1001
+ Q=SA_B_3_shift_reg_2__1_ VDD=VDD
XSA_B_3_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1002
+ Q=SA_B_3_shift_reg_2__0_ VDD=VDD
XSA_B_3_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1003
+ Q=SA_B_3_shift_reg_1__7_ VDD=VDD
XSA_B_3_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1004
+ Q=SA_B_3_shift_reg_1__6_ VDD=VDD
XSA_B_3_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1005
+ Q=SA_B_3_shift_reg_1__5_ VDD=VDD
XSA_B_3_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1006
+ Q=SA_B_3_shift_reg_1__4_ VDD=VDD
XSA_B_3_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n1007
+ Q=SA_B_3_shift_reg_1__3_ VDD=VDD
XSA_A_3_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n790
+ Q=SA_A_3_shift_reg_0__4_ VDD=VDD
XSA_A_3_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n791
+ Q=SA_A_3_shift_reg_0__3_ VDD=VDD
XSA_A_3_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n792
+ Q=SA_A_3_shift_reg_0__2_ VDD=VDD
XSA_A_3_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n793
+ Q=SA_A_3_shift_reg_0__1_ VDD=VDD
XSA_A_3_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n794
+ Q=SA_A_3_shift_reg_0__0_ VDD=VDD
XSA_B_0_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n851
+ Q=SA_B_0_shift_reg_5__7_ VDD=VDD
XSA_B_0_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n804
+ Q=SA_B_0_shift_reg_5__6_ VDD=VDD
XSA_B_0_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n805
+ Q=SA_B_0_shift_reg_5__5_ VDD=VDD
XSA_B_0_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n806
+ Q=SA_B_0_shift_reg_5__4_ VDD=VDD
XSA_B_0_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n807
+ Q=SA_B_0_shift_reg_5__3_ VDD=VDD
XSA_B_0_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n808
+ Q=SA_B_0_shift_reg_5__2_ VDD=VDD
XSA_B_0_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n809
+ Q=SA_B_0_shift_reg_5__1_ VDD=VDD
XSA_B_0_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n810
+ Q=SA_B_0_shift_reg_5__0_ VDD=VDD
XSA_B_0_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n811
+ Q=SA_B_0_shift_reg_4__7_ VDD=VDD
XSA_B_0_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n812
+ Q=SA_B_0_shift_reg_4__6_ VDD=VDD
XSA_B_0_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n813
+ Q=SA_B_0_shift_reg_4__5_ VDD=VDD
XSA_B_0_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n814
+ Q=SA_B_0_shift_reg_4__4_ VDD=VDD
XSA_B_0_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n815
+ Q=SA_B_0_shift_reg_4__3_ VDD=VDD
XSA_B_0_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n816
+ Q=SA_B_0_shift_reg_4__2_ VDD=VDD
XSA_B_0_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n817
+ Q=SA_B_0_shift_reg_4__1_ VDD=VDD
XSA_B_0_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n818
+ Q=SA_B_0_shift_reg_4__0_ VDD=VDD
XSA_B_0_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n819
+ Q=SA_B_0_shift_reg_3__7_ VDD=VDD
XSA_B_0_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n820
+ Q=SA_B_0_shift_reg_3__6_ VDD=VDD
XSA_B_0_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n821
+ Q=SA_B_0_shift_reg_3__5_ VDD=VDD
XSA_B_0_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n822
+ Q=SA_B_0_shift_reg_3__4_ VDD=VDD
XSA_B_0_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n823
+ Q=SA_B_0_shift_reg_3__3_ VDD=VDD
XSA_B_0_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n824
+ Q=SA_B_0_shift_reg_3__2_ VDD=VDD
XSA_B_0_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n825
+ Q=SA_B_0_shift_reg_3__1_ VDD=VDD
XSA_B_0_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n826
+ Q=SA_B_0_shift_reg_3__0_ VDD=VDD
XSA_B_0_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n827
+ Q=SA_B_0_shift_reg_2__7_ VDD=VDD
XSA_B_0_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n828
+ Q=SA_B_0_shift_reg_2__6_ VDD=VDD
XSA_B_0_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n829
+ Q=SA_B_0_shift_reg_2__5_ VDD=VDD
XSA_B_0_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n830
+ Q=SA_B_0_shift_reg_2__4_ VDD=VDD
XSA_B_0_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n831
+ Q=SA_B_0_shift_reg_2__3_ VDD=VDD
XSA_B_0_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n832
+ Q=SA_B_0_shift_reg_2__2_ VDD=VDD
XSA_B_0_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n833
+ Q=SA_B_0_shift_reg_2__1_ VDD=VDD
XSA_B_0_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n834
+ Q=SA_B_0_shift_reg_2__0_ VDD=VDD
XSA_B_0_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n835
+ Q=SA_B_0_shift_reg_1__7_ VDD=VDD
XSA_B_0_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n836
+ Q=SA_B_0_shift_reg_1__6_ VDD=VDD
XSA_B_0_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n837
+ Q=SA_B_0_shift_reg_1__5_ VDD=VDD
XSA_B_0_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n838
+ Q=SA_B_0_shift_reg_1__4_ VDD=VDD
XSA_B_0_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n839
+ Q=SA_B_0_shift_reg_1__3_ VDD=VDD
XSA_B_0_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n840
+ Q=SA_B_0_shift_reg_1__2_ VDD=VDD
XSA_B_0_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n841
+ Q=SA_B_0_shift_reg_1__1_ VDD=VDD
XSA_B_0_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n842
+ Q=SA_B_0_shift_reg_1__0_ VDD=VDD
XSA_B_0_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n843
+ Q=SA_B_0_shift_reg_0__7_ VDD=VDD
XSA_B_0_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n844
+ Q=SA_B_0_shift_reg_0__6_ VDD=VDD
XSA_B_0_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n845
+ Q=SA_B_0_shift_reg_0__5_ VDD=VDD
XSA_B_0_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n846
+ Q=SA_B_0_shift_reg_0__4_ VDD=VDD
XSA_B_0_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n847
+ Q=SA_B_0_shift_reg_0__3_ VDD=VDD
XSA_B_0_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n848
+ Q=SA_B_0_shift_reg_0__2_ VDD=VDD
XSA_B_0_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n849
+ Q=SA_B_0_shift_reg_0__1_ VDD=VDD
XSA_B_0_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n850
+ Q=SA_B_0_shift_reg_0__0_ VDD=VDD
XSA_B_1_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n907
+ Q=SA_B_1_shift_reg_5__7_ VDD=VDD
XSA_B_1_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n860
+ Q=SA_B_1_shift_reg_5__6_ VDD=VDD
XSA_B_1_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n861
+ Q=SA_B_1_shift_reg_5__5_ VDD=VDD
XSA_B_1_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n862
+ Q=SA_B_1_shift_reg_5__4_ VDD=VDD
XSA_B_1_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n863
+ Q=SA_B_1_shift_reg_5__3_ VDD=VDD
XSA_B_1_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n864
+ Q=SA_B_1_shift_reg_5__2_ VDD=VDD
XSA_B_1_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n865
+ Q=SA_B_1_shift_reg_5__1_ VDD=VDD
XSA_B_1_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n866
+ Q=SA_B_1_shift_reg_5__0_ VDD=VDD
XSA_B_1_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n867
+ Q=SA_B_1_shift_reg_4__7_ VDD=VDD
XSA_B_1_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n868
+ Q=SA_B_1_shift_reg_4__6_ VDD=VDD
XSA_B_1_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n869
+ Q=SA_B_1_shift_reg_4__5_ VDD=VDD
XSA_B_1_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n870
+ Q=SA_B_1_shift_reg_4__4_ VDD=VDD
XSA_B_1_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n871
+ Q=SA_B_1_shift_reg_4__3_ VDD=VDD
XSA_B_1_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n872
+ Q=SA_B_1_shift_reg_4__2_ VDD=VDD
XSA_B_1_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n873
+ Q=SA_B_1_shift_reg_4__1_ VDD=VDD
XSA_B_1_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n874
+ Q=SA_B_1_shift_reg_4__0_ VDD=VDD
XSA_B_1_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n875
+ Q=SA_B_1_shift_reg_3__7_ VDD=VDD
XSA_B_1_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n876
+ Q=SA_B_1_shift_reg_3__6_ VDD=VDD
XSA_B_1_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n877
+ Q=SA_B_1_shift_reg_3__5_ VDD=VDD
XSA_B_1_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n878
+ Q=SA_B_1_shift_reg_3__4_ VDD=VDD
XSA_B_1_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n879
+ Q=SA_B_1_shift_reg_3__3_ VDD=VDD
XSA_B_1_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n880
+ Q=SA_B_1_shift_reg_3__2_ VDD=VDD
XSA_B_1_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n881
+ Q=SA_B_1_shift_reg_3__1_ VDD=VDD
XSA_B_1_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n882
+ Q=SA_B_1_shift_reg_3__0_ VDD=VDD
XSA_B_1_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n883
+ Q=SA_B_1_shift_reg_2__7_ VDD=VDD
XSA_B_1_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n884
+ Q=SA_B_1_shift_reg_2__6_ VDD=VDD
XSA_B_1_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n885
+ Q=SA_B_1_shift_reg_2__5_ VDD=VDD
XSA_B_1_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n886
+ Q=SA_B_1_shift_reg_2__4_ VDD=VDD
XSA_B_1_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n887
+ Q=SA_B_1_shift_reg_2__3_ VDD=VDD
XSA_B_1_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n888
+ Q=SA_B_1_shift_reg_2__2_ VDD=VDD
XSA_B_1_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n889
+ Q=SA_B_1_shift_reg_2__1_ VDD=VDD
XSA_B_1_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n890
+ Q=SA_B_1_shift_reg_2__0_ VDD=VDD
XSA_B_1_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n891
+ Q=SA_B_1_shift_reg_1__7_ VDD=VDD
XSA_B_1_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n892
+ Q=SA_B_1_shift_reg_1__6_ VDD=VDD
XSA_B_1_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n893
+ Q=SA_B_1_shift_reg_1__5_ VDD=VDD
XSA_B_1_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n894
+ Q=SA_B_1_shift_reg_1__4_ VDD=VDD
XSA_B_1_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9 D=n895
+ Q=SA_B_1_shift_reg_1__3_ VDD=VDD
XSA_B_1_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n896
+ Q=SA_B_1_shift_reg_1__2_ VDD=VDD
XSA_B_1_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n897
+ Q=SA_B_1_shift_reg_1__1_ VDD=VDD
XSA_B_1_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n898
+ Q=SA_B_1_shift_reg_1__0_ VDD=VDD
XSA_A_2_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n692
+ Q=SA_A_2_shift_reg_5__6_ VDD=VDD
XSA_A_2_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n693
+ Q=SA_A_2_shift_reg_5__5_ VDD=VDD
XSA_A_2_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n694
+ Q=SA_A_2_shift_reg_5__4_ VDD=VDD
XSA_A_2_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n695
+ Q=SA_A_2_shift_reg_5__3_ VDD=VDD
XSA_A_2_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n696
+ Q=SA_A_2_shift_reg_5__2_ VDD=VDD
XSA_A_2_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n697
+ Q=SA_A_2_shift_reg_5__1_ VDD=VDD
XSA_A_2_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n698
+ Q=SA_A_2_shift_reg_5__0_ VDD=VDD
XSA_A_2_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n699
+ Q=SA_A_2_shift_reg_4__7_ VDD=VDD
XSA_A_2_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n700
+ Q=SA_A_2_shift_reg_4__6_ VDD=VDD
XSA_A_2_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n701
+ Q=SA_A_2_shift_reg_4__5_ VDD=VDD
XSA_A_2_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n702
+ Q=SA_A_2_shift_reg_4__4_ VDD=VDD
XSA_A_2_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n4808
+ Q=SA_A_2_shift_reg_4__3_ VDD=VDD
XSA_A_2_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n704
+ Q=SA_A_2_shift_reg_4__2_ VDD=VDD
XSA_A_2_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n705
+ Q=SA_A_2_shift_reg_4__1_ VDD=VDD
XSA_A_2_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n706
+ Q=SA_A_2_shift_reg_4__0_ VDD=VDD
XSA_A_2_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n707
+ Q=SA_A_2_shift_reg_3__7_ VDD=VDD
XSA_A_2_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n708
+ Q=SA_A_2_shift_reg_3__6_ VDD=VDD
XSA_A_2_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n709
+ Q=SA_A_2_shift_reg_3__5_ VDD=VDD
XSA_A_2_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n710
+ Q=SA_A_2_shift_reg_3__4_ VDD=VDD
XSA_A_2_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n711
+ Q=SA_A_2_shift_reg_3__3_ VDD=VDD
XSA_A_2_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n712
+ Q=SA_A_2_shift_reg_3__2_ VDD=VDD
XSA_A_2_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n713
+ Q=SA_A_2_shift_reg_3__1_ VDD=VDD
XSA_A_2_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n714
+ Q=SA_A_2_shift_reg_3__0_ VDD=VDD
XSA_A_2_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n715
+ Q=SA_A_2_shift_reg_2__7_ VDD=VDD
XSA_A_2_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n716
+ Q=SA_A_2_shift_reg_2__6_ VDD=VDD
XSA_A_2_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n717
+ Q=SA_A_2_shift_reg_2__5_ VDD=VDD
XSA_A_2_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n718
+ Q=SA_A_2_shift_reg_2__4_ VDD=VDD
XSA_A_2_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n719
+ Q=SA_A_2_shift_reg_2__3_ VDD=VDD
XSA_A_2_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n720
+ Q=SA_A_2_shift_reg_2__2_ VDD=VDD
XSA_A_2_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n721
+ Q=SA_A_2_shift_reg_2__1_ VDD=VDD
XSA_A_2_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n722
+ Q=SA_A_2_shift_reg_2__0_ VDD=VDD
XSA_A_2_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n723
+ Q=SA_A_2_shift_reg_1__7_ VDD=VDD
XSA_A_2_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n724
+ Q=SA_A_2_shift_reg_1__6_ VDD=VDD
XSA_A_2_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n725
+ Q=SA_A_2_shift_reg_1__5_ VDD=VDD
XSA_A_2_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n726
+ Q=SA_A_2_shift_reg_1__4_ VDD=VDD
XSA_A_2_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n727
+ Q=SA_A_2_shift_reg_1__3_ VDD=VDD
XSA_A_2_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n728
+ Q=SA_A_2_shift_reg_1__2_ VDD=VDD
XSA_A_2_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n729
+ Q=SA_A_2_shift_reg_1__1_ VDD=VDD
XSA_A_2_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n730
+ Q=SA_A_2_shift_reg_1__0_ VDD=VDD
XSA_A_2_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n731
+ Q=SA_A_2_shift_reg_0__7_ VDD=VDD
XSA_A_2_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n732
+ Q=SA_A_2_shift_reg_0__6_ VDD=VDD
XSA_A_2_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n733
+ Q=SA_A_2_shift_reg_0__5_ VDD=VDD
XSA_A_2_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n734
+ Q=SA_A_2_shift_reg_0__4_ VDD=VDD
XSA_A_2_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n735
+ Q=SA_A_2_shift_reg_0__3_ VDD=VDD
XSA_A_2_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n736
+ Q=SA_A_2_shift_reg_0__2_ VDD=VDD
XSA_A_2_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n737
+ Q=SA_A_2_shift_reg_0__1_ VDD=VDD
XSA_A_2_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n738
+ Q=SA_A_2_shift_reg_0__0_ VDD=VDD
XSA_A_3_shift_reg_reg_6__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n741
+ Q=SA_row_3<6> VDD=VDD
XSA_A_3_shift_reg_reg_6__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n742
+ Q=SA_row_3<5> VDD=VDD
XSA_A_3_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n743
+ Q=SA_row_3<4> VDD=VDD
XSA_A_3_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n795
+ Q=SA_A_3_shift_reg_5__7_ VDD=VDD
XSA_A_3_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n748
+ Q=SA_A_3_shift_reg_5__6_ VDD=VDD
XSA_A_3_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n749
+ Q=SA_A_3_shift_reg_5__5_ VDD=VDD
XSA_A_3_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n750
+ Q=SA_A_3_shift_reg_5__4_ VDD=VDD
XSA_A_3_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n751
+ Q=SA_A_3_shift_reg_5__3_ VDD=VDD
XSA_A_3_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n752
+ Q=SA_A_3_shift_reg_5__2_ VDD=VDD
XSA_A_3_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n753
+ Q=SA_A_3_shift_reg_5__1_ VDD=VDD
XSA_A_3_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n754
+ Q=SA_A_3_shift_reg_5__0_ VDD=VDD
XSA_A_3_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n755
+ Q=SA_A_3_shift_reg_4__7_ VDD=VDD
XSA_A_3_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n756
+ Q=SA_A_3_shift_reg_4__6_ VDD=VDD
XSA_A_3_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n757
+ Q=SA_A_3_shift_reg_4__5_ VDD=VDD
XSA_A_3_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n758
+ Q=SA_A_3_shift_reg_4__4_ VDD=VDD
XSA_A_3_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n759
+ Q=SA_A_3_shift_reg_4__3_ VDD=VDD
XSA_A_3_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n760
+ Q=SA_A_3_shift_reg_4__2_ VDD=VDD
XSA_A_3_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n761
+ Q=SA_A_3_shift_reg_4__1_ VDD=VDD
XSA_A_3_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n762
+ Q=SA_A_3_shift_reg_4__0_ VDD=VDD
XSA_A_3_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n763
+ Q=SA_A_3_shift_reg_3__7_ VDD=VDD
XSA_A_3_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n764
+ Q=SA_A_3_shift_reg_3__6_ VDD=VDD
XSA_A_3_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n765
+ Q=SA_A_3_shift_reg_3__5_ VDD=VDD
XSA_A_3_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n766
+ Q=SA_A_3_shift_reg_3__4_ VDD=VDD
XSA_A_3_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n767
+ Q=SA_A_3_shift_reg_3__3_ VDD=VDD
XSA_A_3_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n768
+ Q=SA_A_3_shift_reg_3__2_ VDD=VDD
XSA_A_3_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n769
+ Q=SA_A_3_shift_reg_3__1_ VDD=VDD
XSA_A_3_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n770
+ Q=SA_A_3_shift_reg_3__0_ VDD=VDD
XSA_A_3_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n771
+ Q=SA_A_3_shift_reg_2__7_ VDD=VDD
XSA_A_3_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n772
+ Q=SA_A_3_shift_reg_2__6_ VDD=VDD
XSA_A_3_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n773
+ Q=SA_A_3_shift_reg_2__5_ VDD=VDD
XSA_A_3_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n774
+ Q=SA_A_3_shift_reg_2__4_ VDD=VDD
XSA_A_3_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n775
+ Q=SA_A_3_shift_reg_2__3_ VDD=VDD
XSA_A_3_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n776
+ Q=SA_A_3_shift_reg_2__2_ VDD=VDD
XSA_A_3_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n777
+ Q=SA_A_3_shift_reg_2__1_ VDD=VDD
XSA_A_3_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n778
+ Q=SA_A_3_shift_reg_2__0_ VDD=VDD
XSA_A_3_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n779
+ Q=SA_A_3_shift_reg_1__7_ VDD=VDD
XSA_A_3_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n780
+ Q=SA_A_3_shift_reg_1__6_ VDD=VDD
XSA_A_3_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n781
+ Q=SA_A_3_shift_reg_1__5_ VDD=VDD
XSA_A_3_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n782
+ Q=SA_A_3_shift_reg_1__4_ VDD=VDD
XSA_A_3_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n783
+ Q=SA_A_3_shift_reg_1__3_ VDD=VDD
XSA_A_3_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n784
+ Q=SA_A_3_shift_reg_1__2_ VDD=VDD
XSA_A_3_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n785
+ Q=SA_A_3_shift_reg_1__1_ VDD=VDD
XSA_A_3_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n786
+ Q=SA_A_3_shift_reg_1__0_ VDD=VDD
XSA_A_3_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n787
+ Q=SA_A_3_shift_reg_0__7_ VDD=VDD
XSA_A_3_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n788
+ Q=SA_A_3_shift_reg_0__6_ VDD=VDD
XSA_A_3_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n789
+ Q=SA_A_3_shift_reg_0__5_ VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N16 Q=SA_core_shift_wire<94> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_6_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N16 Q=SA_core_shift_wire<86> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_6_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_3_0_N16 Q=SA_core_shift_wire<78> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N15 Q=SA_core_shift_wire<93> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N15 Q=SA_core_shift_wire<85> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N15 Q=SA_core_shift_wire<77> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N14 Q=SA_core_shift_wire<92> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N14 Q=SA_core_shift_wire<84> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N14 Q=SA_core_shift_wire<76> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N13 Q=SA_core_shift_wire<91> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N13 Q=SA_core_shift_wire<83> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N13 Q=SA_core_shift_wire<75> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N12 Q=SA_core_shift_wire<90> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N12 Q=SA_core_shift_wire<82> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N12 Q=SA_core_shift_wire<74> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N11 Q=SA_core_shift_wire<89> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N11 Q=SA_core_shift_wire<81> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N11 Q=SA_core_shift_wire<73> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_0_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N10 Q=SA_core_shift_wire<88> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N10 Q=SA_core_shift_wire<80> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N10 Q=SA_core_shift_wire<72> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N25 Q=SA_core_connect<7> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N24 Q=SA_core_connect<6> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N23 Q=SA_core_connect<5> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=SA_core_pe_0_0_N22 Q=SA_core_connect<4> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=SA_core_pe_0_0_N21 Q=SA_core_connect<3> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N20 Q=SA_core_connect<2> VDD=VDD
XSA_core_pe_0_0_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N19 Q=SA_core_connect<1> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_0_0_N33 Q=SA_core_connect<103> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_0_0_N31 Q=SA_core_connect<101> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N30 Q=SA_core_connect<100> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N29 Q=SA_core_connect<99> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N28 Q=SA_core_connect<98> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N26 Q=SA_core_connect<96> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=SA_core_pe_0_0_N17 Q=SA_core_shift_wire<7> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=SA_core_pe_0_0_N16 Q=SA_core_shift_wire<6> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N13 Q=SA_core_shift_wire<3> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N12 Q=SA_core_shift_wire<2> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N11 Q=SA_core_shift_wire<1> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N10 Q=SA_core_shift_wire<0> VDD=VDD
XSA_A_1_shift_reg_reg_6__6_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n629
+ Q=SA_row_1<6> VDD=VDD
XSA_A_1_shift_reg_reg_6__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n630
+ Q=SA_row_1<5> VDD=VDD
XSA_A_1_shift_reg_reg_6__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n631
+ Q=SA_row_1<4> VDD=VDD
XSA_A_1_shift_reg_reg_6__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n634
+ Q=SA_row_1<1> VDD=VDD
XSA_A_1_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n683
+ Q=SA_A_1_shift_reg_5__7_ VDD=VDD
XSA_A_1_shift_reg_reg_5__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n636
+ Q=SA_A_1_shift_reg_5__6_ VDD=VDD
XSA_A_1_shift_reg_reg_5__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n637
+ Q=SA_A_1_shift_reg_5__5_ VDD=VDD
XSA_A_1_shift_reg_reg_5__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n638
+ Q=SA_A_1_shift_reg_5__4_ VDD=VDD
XSA_A_1_shift_reg_reg_5__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n639
+ Q=SA_A_1_shift_reg_5__3_ VDD=VDD
XSA_A_1_shift_reg_reg_5__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n640
+ Q=SA_A_1_shift_reg_5__2_ VDD=VDD
XSA_A_1_shift_reg_reg_5__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n641
+ Q=SA_A_1_shift_reg_5__1_ VDD=VDD
XSA_A_1_shift_reg_reg_5__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n642
+ Q=SA_A_1_shift_reg_5__0_ VDD=VDD
XSA_A_1_shift_reg_reg_4__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n643
+ Q=SA_A_1_shift_reg_4__7_ VDD=VDD
XSA_A_1_shift_reg_reg_4__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n644
+ Q=SA_A_1_shift_reg_4__6_ VDD=VDD
XSA_A_1_shift_reg_reg_4__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n645
+ Q=SA_A_1_shift_reg_4__5_ VDD=VDD
XSA_A_1_shift_reg_reg_4__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n646
+ Q=SA_A_1_shift_reg_4__4_ VDD=VDD
XSA_A_1_shift_reg_reg_4__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n647
+ Q=SA_A_1_shift_reg_4__3_ VDD=VDD
XSA_A_1_shift_reg_reg_4__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n648
+ Q=SA_A_1_shift_reg_4__2_ VDD=VDD
XSA_A_1_shift_reg_reg_4__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n649
+ Q=SA_A_1_shift_reg_4__1_ VDD=VDD
XSA_A_1_shift_reg_reg_4__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n650
+ Q=SA_A_1_shift_reg_4__0_ VDD=VDD
XSA_A_1_shift_reg_reg_3__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n651
+ Q=SA_A_1_shift_reg_3__7_ VDD=VDD
XSA_A_1_shift_reg_reg_3__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n652
+ Q=SA_A_1_shift_reg_3__6_ VDD=VDD
XSA_A_1_shift_reg_reg_3__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n653
+ Q=SA_A_1_shift_reg_3__5_ VDD=VDD
XSA_A_1_shift_reg_reg_3__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n654
+ Q=SA_A_1_shift_reg_3__4_ VDD=VDD
XSA_A_1_shift_reg_reg_3__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n655
+ Q=SA_A_1_shift_reg_3__3_ VDD=VDD
XSA_A_1_shift_reg_reg_3__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n656
+ Q=SA_A_1_shift_reg_3__2_ VDD=VDD
XSA_A_1_shift_reg_reg_3__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n657
+ Q=SA_A_1_shift_reg_3__1_ VDD=VDD
XSA_A_1_shift_reg_reg_3__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n658
+ Q=SA_A_1_shift_reg_3__0_ VDD=VDD
XSA_A_1_shift_reg_reg_2__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n659
+ Q=SA_A_1_shift_reg_2__7_ VDD=VDD
XSA_A_1_shift_reg_reg_2__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n660
+ Q=SA_A_1_shift_reg_2__6_ VDD=VDD
XSA_A_1_shift_reg_reg_2__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n661
+ Q=SA_A_1_shift_reg_2__5_ VDD=VDD
XSA_A_1_shift_reg_reg_2__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n662
+ Q=SA_A_1_shift_reg_2__4_ VDD=VDD
XSA_A_1_shift_reg_reg_2__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n663
+ Q=SA_A_1_shift_reg_2__3_ VDD=VDD
XSA_A_1_shift_reg_reg_2__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n664
+ Q=SA_A_1_shift_reg_2__2_ VDD=VDD
XSA_A_1_shift_reg_reg_2__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n665
+ Q=SA_A_1_shift_reg_2__1_ VDD=VDD
XSA_A_1_shift_reg_reg_2__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n666
+ Q=SA_A_1_shift_reg_2__0_ VDD=VDD
XSA_A_1_shift_reg_reg_1__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n667
+ Q=SA_A_1_shift_reg_1__7_ VDD=VDD
XSA_A_1_shift_reg_reg_1__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n668
+ Q=SA_A_1_shift_reg_1__6_ VDD=VDD
XSA_A_1_shift_reg_reg_1__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n669
+ Q=SA_A_1_shift_reg_1__5_ VDD=VDD
XSA_A_1_shift_reg_reg_1__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n670
+ Q=SA_A_1_shift_reg_1__4_ VDD=VDD
XSA_A_1_shift_reg_reg_1__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n671
+ Q=SA_A_1_shift_reg_1__3_ VDD=VDD
XSA_A_1_shift_reg_reg_1__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n672
+ Q=SA_A_1_shift_reg_1__2_ VDD=VDD
XSA_A_1_shift_reg_reg_1__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n673
+ Q=SA_A_1_shift_reg_1__1_ VDD=VDD
XSA_A_1_shift_reg_reg_1__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n674
+ Q=SA_A_1_shift_reg_1__0_ VDD=VDD
XSA_A_1_shift_reg_reg_0__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n675
+ Q=SA_A_1_shift_reg_0__7_ VDD=VDD
XSA_A_1_shift_reg_reg_0__6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n676
+ Q=SA_A_1_shift_reg_0__6_ VDD=VDD
XSA_A_1_shift_reg_reg_0__5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n677
+ Q=SA_A_1_shift_reg_0__5_ VDD=VDD
XSA_A_1_shift_reg_reg_0__4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n678
+ Q=SA_A_1_shift_reg_0__4_ VDD=VDD
XSA_A_1_shift_reg_reg_0__3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n679
+ Q=SA_A_1_shift_reg_0__3_ VDD=VDD
XSA_A_1_shift_reg_reg_0__2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n680
+ Q=SA_A_1_shift_reg_0__2_ VDD=VDD
XSA_A_1_shift_reg_reg_0__1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n681
+ Q=SA_A_1_shift_reg_0__1_ VDD=VDD
XSA_A_1_shift_reg_reg_0__0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n682
+ Q=SA_A_1_shift_reg_0__0_ VDD=VDD
XSA_A_2_shift_reg_reg_5__7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n739
+ Q=SA_A_2_shift_reg_5__7_ VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N29 Q=SA_core_connect<107> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_0_N28 Q=SA_core_connect<114> VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N28 Q=SA_core_connect<106> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_0_N26 Q=SA_core_connect<112> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N17 Q=SA_core_output_row_1<7> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_7_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N17 Q=SA_core_shift_wire<47> VDD=VDD
XSA_core_pe_1_1_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_1_N17 Q=SA_core_shift_wire<39> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N16 Q=SA_core_output_row_1<6> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_6_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N16 Q=SA_core_shift_wire<46> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N15 Q=SA_core_output_row_1<5> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N15 Q=SA_core_shift_wire<45> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N15 Q=SA_core_shift_wire<29> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N14 Q=SA_core_output_row_1<4> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N14 Q=SA_core_shift_wire<44> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N14 Q=SA_core_shift_wire<28> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N13 Q=SA_core_output_row_1<3> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N13 Q=SA_core_shift_wire<43> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N13 Q=SA_core_shift_wire<27> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N12 Q=SA_core_output_row_1<2> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N12 Q=SA_core_shift_wire<42> VDD=VDD
XSA_core_pe_1_1_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N12 Q=SA_core_shift_wire<34> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N12 Q=SA_core_shift_wire<26> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N11 Q=SA_core_output_row_1<1> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N11 Q=SA_core_shift_wire<41> VDD=VDD
XSA_core_pe_1_1_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N11 Q=SA_core_shift_wire<33> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N11 Q=SA_core_shift_wire<25> VDD=VDD
XSA_core_pe_1_3_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N10 Q=SA_core_output_row_1<0> VDD=VDD
XSA_core_pe_1_2_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N10 Q=SA_core_shift_wire<40> VDD=VDD
XSA_core_pe_1_1_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N10 Q=SA_core_shift_wire<32> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N10 Q=SA_core_shift_wire<24> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_2_N25 Q=SA_core_connect<71> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N25 Q=SA_core_connect<63> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_2_N24 Q=SA_core_connect<70> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N23 Q=SA_core_connect<69> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N23 Q=SA_core_connect<61> VDD=VDD
XSA_core_pe_2_0_Aij_o_reg_5_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N23 Q=SA_core_connect<53> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N22 Q=SA_core_connect<68> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N22 Q=SA_core_connect<60> VDD=VDD
XSA_core_pe_2_0_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N22 Q=SA_core_connect<52> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N21 Q=SA_core_connect<67> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N21 Q=SA_core_connect<59> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N20 Q=SA_core_connect<58> VDD=VDD
XSA_core_pe_2_0_Aij_o_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N20 Q=SA_core_connect<50> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N19 Q=SA_core_connect<65> VDD=VDD
XSA_core_pe_2_1_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N19 Q=SA_core_connect<57> VDD=VDD
XSA_core_pe_2_0_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N19 Q=SA_core_connect<49> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N17 Q=SA_core_output_row_2<7> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_2_N17 Q=SA_core_shift_wire<71> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_1_N17 Q=SA_core_shift_wire<63> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N16 Q=SA_core_output_row_2<6> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N16 Q=SA_core_shift_wire<70> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_1_N16 Q=SA_core_shift_wire<62> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N15 Q=SA_core_output_row_2<5> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_5_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N15 Q=SA_core_shift_wire<69> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N15 Q=SA_core_shift_wire<61> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N14 Q=SA_core_output_row_2<4> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N14 Q=SA_core_shift_wire<68> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_1_N14 Q=SA_core_shift_wire<60> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N13 Q=SA_core_output_row_2<3> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N13 Q=SA_core_shift_wire<59> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N12 Q=SA_core_shift_wire<58> VDD=VDD
XSA_core_pe_2_0_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_0_N12 Q=SA_core_shift_wire<50> VDD=VDD
XSA_core_pe_2_3_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N11 Q=SA_core_output_row_2<1> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_2_N11 Q=SA_core_shift_wire<65> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N11 Q=SA_core_shift_wire<57> VDD=VDD
XSA_core_pe_2_0_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6 D=n4801
+ Q=SA_core_shift_wire<49> VDD=VDD
XSA_core_pe_2_2_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N10 Q=SA_core_shift_wire<64> VDD=VDD
XSA_core_pe_2_1_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N10 Q=SA_core_shift_wire<56> VDD=VDD
XSA_core_pe_2_0_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N10 Q=SA_core_shift_wire<48> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_3_2_N25 Q=SA_core_connect<95> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N25 Q=SA_core_connect<87> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N25 Q=SA_core_connect<79> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_3_2_N24 Q=SA_core_connect<94> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N24 Q=SA_core_connect<86> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N24 Q=SA_core_connect<78> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N23 Q=SA_core_connect<93> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N23 Q=SA_core_connect<85> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N23 Q=SA_core_connect<77> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N22 Q=SA_core_connect<92> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N22 Q=SA_core_connect<84> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N22 Q=SA_core_connect<76> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N21 Q=SA_core_connect<91> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N21 Q=SA_core_connect<83> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N21 Q=SA_core_connect<75> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N20 Q=SA_core_connect<90> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N20 Q=SA_core_connect<82> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N20 Q=SA_core_connect<74> VDD=VDD
XSA_core_pe_3_2_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N19 Q=SA_core_connect<89> VDD=VDD
XSA_core_pe_3_1_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N19 Q=SA_core_connect<81> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_0_N19 Q=SA_core_connect<73> VDD=VDD
XSA_core_pe_3_2_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_2_N17 Q=SA_core_shift_wire<95> VDD=VDD
XSA_core_pe_3_1_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_1_N17 Q=SA_core_shift_wire<87> VDD=VDD
XSA_core_pe_3_0_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_3_0_N17 Q=SA_core_shift_wire<79> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_1_N22 Q=SA_core_connect<12> VDD=VDD
XSA_core_pe_0_2_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N21 Q=SA_core_connect<19> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_1_N21 Q=SA_core_connect<11> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N20 Q=SA_core_connect<10> VDD=VDD
XSA_core_pe_0_2_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N19 Q=SA_core_connect<17> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N19 Q=SA_core_connect<9> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N18 Q=SA_core_connect<8> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N33 Q=SA_core_connect<143> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N33 Q=SA_core_connect<127> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N32 Q=SA_core_connect<142> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_1_N32 Q=SA_core_connect<134> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N32 Q=SA_core_connect<126> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N31 Q=SA_core_connect<141> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N31 Q=SA_core_connect<133> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N31 Q=SA_core_connect<125> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N30 Q=SA_core_connect<140> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N30 Q=SA_core_connect<132> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N30 Q=SA_core_connect<124> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N29 Q=SA_core_connect<139> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N29 Q=SA_core_connect<131> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N29 Q=SA_core_connect<123> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N28 Q=SA_core_connect<138> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N28 Q=SA_core_connect<130> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N28 Q=SA_core_connect<122> VDD=VDD
XSA_core_pe_2_1_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_1_N26 Q=SA_core_connect<136> VDD=VDD
XSA_core_pe_1_1_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N26 Q=SA_core_connect<128> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N17 Q=SA_core_shift_wire<23> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_7_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I4
+ D=SA_core_pe_0_1_N17 Q=SA_core_shift_wire<15> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N16 Q=SA_core_shift_wire<22> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_1_N16 Q=SA_core_shift_wire<14> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N15 Q=SA_core_shift_wire<21> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_1_N15 Q=SA_core_shift_wire<13> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N14 Q=SA_core_shift_wire<20> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_1_N14 Q=SA_core_shift_wire<12> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N13 Q=SA_core_shift_wire<19> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N13 Q=SA_core_shift_wire<11> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N12 Q=SA_core_shift_wire<18> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N12 Q=SA_core_shift_wire<10> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N11 Q=SA_core_shift_wire<17> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N11 Q=SA_core_shift_wire<9> VDD=VDD
XSA_core_pe_0_2_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N10 Q=SA_core_shift_wire<16> VDD=VDD
XSA_core_pe_0_1_Cij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N10 Q=SA_core_shift_wire<8> VDD=VDD
XSA_core_pe_2_2_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_2_N33 Q=SA_core_connect<167> VDD=VDD
XSA_core_pe_2_2_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_2_N32 Q=SA_core_connect<166> VDD=VDD
XSA_core_pe_1_2_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N31 Q=SA_core_connect<157> VDD=VDD
XSA_core_pe_0_2_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N31 Q=SA_core_connect<149> VDD=VDD
XSA_core_pe_1_2_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N30 Q=SA_core_connect<156> VDD=VDD
XSA_core_pe_0_2_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N30 Q=SA_core_connect<148> VDD=VDD
XSA_core_pe_1_2_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N29 Q=SA_core_connect<155> VDD=VDD
XSA_core_pe_0_2_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_2_N29 Q=SA_core_connect<147> VDD=VDD
XSA_core_pe_1_2_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N28 Q=SA_core_connect<154> VDD=VDD
XSA_core_pe_1_2_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N26 Q=SA_core_connect<152> VDD=VDD
XSA_core_pe_2_3_Bij_o_reg_7_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_2_3_N33 Q=SA_core_connect<191> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N33 Q=SA_core_connect<183> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N33 Q=SA_core_connect<175> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N32 Q=SA_core_connect<182> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N31 Q=SA_core_connect<181> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N31 Q=SA_core_connect<173> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N30 Q=SA_core_connect<180> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N30 Q=SA_core_connect<172> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N29 Q=SA_core_connect<179> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N29 Q=SA_core_connect<171> VDD=VDD
XSA_core_pe_1_3_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_3_N28 Q=SA_core_connect<178> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N28 Q=SA_core_connect<170> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N26 Q=SA_core_connect<168> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N25 Q=SA_core_connect<47> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_7_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_1_N25 Q=SA_core_connect<39> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N25 Q=SA_core_connect<31> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N24 Q=SA_core_connect<46> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_1_N24 Q=SA_core_connect<38> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N23 Q=SA_core_connect<45> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N23 Q=SA_core_connect<37> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N23 Q=SA_core_connect<29> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N22 Q=SA_core_connect<44> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N22 Q=SA_core_connect<36> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N22 Q=SA_core_connect<28> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N21 Q=SA_core_connect<43> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N21 Q=SA_core_connect<35> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N20 Q=SA_core_connect<42> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N20 Q=SA_core_connect<34> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N20 Q=SA_core_connect<26> VDD=VDD
XSA_core_pe_1_2_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_2_N19 Q=SA_core_connect<41> VDD=VDD
XSA_core_pe_1_1_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_1_1_N19 Q=SA_core_connect<33> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_1_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N19 Q=SA_core_connect<25> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_2_0_N33 Q=SA_core_connect<119> VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N33 Q=SA_core_connect<111> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_2_0_N32 Q=SA_core_connect<118> VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N32 Q=SA_core_connect<110> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_2_0_N31 Q=SA_core_connect<117> VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N31 Q=SA_core_connect<109> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I7
+ D=SA_core_pe_2_0_N30 Q=SA_core_connect<116> VDD=VDD
XSA_core_pe_1_0_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N30 Q=SA_core_connect<108> VDD=VDD
XSA_core_pe_2_0_Bij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_0_N29 Q=SA_core_connect<115> VDD=VDD
XU1561 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3876 ZN=n1175 A2=n4649
XU1560 FA1D0BWP7T $PINS CO=n1167 S=n1149 CI=n1150 B=n4193 VDD=VDD A=n1152
+ VSS=VSS
XU1559 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_0_N14 A2=n4742 A1=n1149
XU1558 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3876 ZN=n1157 A2=n4521
XU1557 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1158 B=n1176 A2=n1148
+ A1=SA_core_shift_wire<4>
XU1556 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_0<1> VDD=VDD A2=n4518
+ A3=SA_core_shift_wire<4> Z=n1176
XU1555 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4644 ZN=n1148 A2=n4519
XU1554 FA1D0BWP7T $PINS CO=n1161 S=n1140 CI=n1145 B=n1146 VDD=VDD A=n1147
+ VSS=VSS
XU1553 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4664 ZN=n1154 A2=n4640
XU1552 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4675 ZN=n1155 A2=n4649
XU1551 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4517 ZN=n1156 A2=n4635
XU1549 FA1D0BWP7T $PINS CO=n1152 S=n1136 CI=n1139 B=n1140 VDD=VDD A=n1141
+ VSS=VSS
XU1548 AOI21D0BWP7T $PINS VSS=VSS A2=n1138 VDD=VDD A1=n1144 B=n1137
+ ZN=SA_core_pe_0_0_N13
XU1547 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4742 A1=n1144 ZN=n1137 A2=n1138
XU1546 AOI22D1BWP7T $PINS B1=n1135 A2=n1142 ZN=n1138 A1=n1136 VDD=VDD B2=n1143
+ VSS=VSS
XU1545 INVD0BWP7T $PINS ZN=n1143 VSS=VSS VDD=VDD I=n1136
XU1544 INVD0BWP7T $PINS ZN=n1142 VSS=VSS VDD=VDD I=n1135
XU1543 FA1D0BWP7T $PINS CO=n1135 S=n1125 CI=n1132 B=n1133 VDD=VDD A=n1134
+ VSS=VSS
XU1542 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1139 B=n1159 A2=n1131
+ A1=SA_core_shift_wire<3>
XU1541 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_0<1> VDD=VDD A2=SA_row_0<2>
+ A3=SA_core_shift_wire<3> Z=n1159
XU1540 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4644 ZN=n1131 A2=n4649
XU1539 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3876 ZN=n1145 A2=n4640
XU1538 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4519 ZN=n1146 A2=n4635
XU1537 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4675 ZN=n1147 A2=n4521
XU1536 INVD0BWP7T $PINS ZN=n1141 VSS=VSS VDD=VDD I=n1130
XU1535 FA1D0BWP7T $PINS CO=n1144 S=n1126 CI=n1127 B=n1128 VDD=VDD A=n1129
+ VSS=VSS
XU1534 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1126 ZN=SA_core_pe_0_0_N12 A2=n4743
XU1533 INVD0BWP7T $PINS ZN=n1127 VSS=VSS VDD=VDD I=n1125
XU1532 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4649 ZN=n1132 A2=n4635
XU1531 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4644 ZN=n1133 A2=n4521
XU1530 MAOI222D1BWP7T $PINS ZN=n1128 C=n1122 B=n4778 VDD=VDD A=n1124 VSS=VSS
XU1529 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1130 A1=SA_core_shift_wire<2>
+ ZN=n1129 A2=n1121
XU1528 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4639 A1=n4674 ZN=n1130
+ A3=SA_core_shift_wire<2>
XU1527 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4675 ZN=n1121 A2=n4640
XU1525 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4742 A1=n4778 ZN=n1119 A2=n1120
XU1524 MAOI22D0BWP7T $PINS A2=n1122 ZN=n1120 A1=n1124 B2=n1124 VDD=VDD B1=n1122
+ VSS=VSS
XU1523 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4521 ZN=n1122 A2=n4635
XU1520 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_0<1> ZN=n1117 A2=n4639
XU1519 INVD0BWP7T $PINS ZN=n1118 VSS=VSS VDD=VDD I=SA_core_shift_wire<1>
XU1518 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1124 A2=n1115 A1=n1116
+ ZN=SA_core_pe_0_0_N10 C=n4743
XU1513 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_0<0> ZN=n1115 A2=n4639
XU1511 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_0_N25 A2=n4731 A1=n4511
XU1509 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N24 A2=n4513
XU1506 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N23 A2=n4515
XU1504 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N22 A2=n4517
XU1502 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N21 A2=n4519
XU1500 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N20 A2=n4649
XU1498 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N19 A2=n4521
XU1496 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N18 A2=n4640
XU1494 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_0_N33 A2=n4731 A1=n4652
XU1492 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N32 A2=n3873
XU1490 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N31 A2=n3874
XU1488 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N30 A2=n4664
XU1486 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N29 A2=n3876
XU1484 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N28 A2=n4675
XU1480 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N27 A2=n4644
XU1474 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_0_N26 A2=n4635
XU1465 INVD0BWP7T $PINS ZN=n3112 VSS=VSS VDD=VDD I=n3113
XU1460 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1108 ZN=shift_out<7> A2=n1107
XU1459 AOI22D1BWP7T $PINS B1=SA_core_output_row_0<7> A2=SA_core_output_row_3<7>
+ ZN=n1107 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1458 AOI22D1BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<7> ZN=n1108 A1=n4816
+ VDD=VDD B2=SA_core_output_row_1<7> VSS=VSS
XU1457 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1105 ZN=shift_out<6> A2=n1104
XU1456 AOI22D1BWP7T $PINS B1=SA_core_output_row_0<6> A2=SA_core_output_row_3<6>
+ ZN=n1104 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1454 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1103 ZN=shift_out<5> A2=n1102
XU1453 AOI22D1BWP7T $PINS B1=SA_core_output_row_0<5> A2=SA_core_output_row_3<5>
+ ZN=n1102 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1451 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1101 ZN=shift_out<4> A2=n1100
XU1449 AOI22D1BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<4> ZN=n1101 A1=n4816
+ VDD=VDD B2=n4828 VSS=VSS
XU1448 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1099 ZN=shift_out<3> A2=n1098
XU1447 AOI22D0BWP7T $PINS B1=SA_core_output_row_0<3> A2=SA_core_output_row_3<3>
+ ZN=n1098 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1446 AOI22D0BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<3> ZN=n1099 A1=n4816
+ VDD=VDD B2=SA_core_output_row_1<3> VSS=VSS
XU1445 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4819 ZN=shift_out<2> A2=n1096
XU1444 AOI22D0BWP7T $PINS B1=SA_core_output_row_0<2> A2=SA_core_output_row_3<2>
+ ZN=n1096 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1442 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1095 ZN=shift_out<1> A2=n1094
XU1441 AOI22D0BWP7T $PINS B1=SA_core_output_row_0<1> A2=SA_core_output_row_3<1>
+ ZN=n1094 A1=n4737 VDD=VDD B2=n4736 VSS=VSS
XU1440 AOI22D0BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<1> ZN=n1095 A1=n4816
+ VDD=VDD B2=SA_core_output_row_1<1> VSS=VSS
XU1439 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1093 ZN=shift_out<0> A2=n1092
XSA_core_pe_0_2_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N25 Q=SA_core_connect<23> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N25 Q=SA_core_connect<15> VDD=VDD
XSA_core_pe_0_2_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N24 Q=SA_core_connect<22> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N24 Q=SA_core_connect<14> VDD=VDD
XSA_core_pe_0_2_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N23 Q=SA_core_connect<21> VDD=VDD
XSA_core_pe_0_1_Aij_o_reg_5_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_1_N23 Q=SA_core_connect<13> VDD=VDD
XSA_core_pe_0_2_Aij_o_reg_4_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I9
+ D=SA_core_pe_0_2_N22 Q=SA_core_connect<20> VDD=VDD
XU1680 FA1D0BWP7T $PINS CO=n1277 S=n1260 CI=n1268 B=n1269 VDD=VDD A=n1270
+ VSS=VSS
XU1679 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3771 ZN=n1282 A2=n4679
XU1677 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3777 ZN=n1283 A2=n4569
XU1676 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3829 ZN=n1284 A2=n3783
XU1673 INVD0BWP7T $PINS ZN=n1265 VSS=VSS VDD=VDD I=n1262
XU1672 FA1D0BWP7T $PINS CO=n1275 S=n1263 CI=n1259 B=n1260 VDD=VDD A=n1261
+ VSS=VSS
XU1669 OAI22D1BWP7T $PINS B1=n4746 A2=n3086 ZN=SA_core_pe_3_2_N13 A1=n1258
+ VDD=VDD B2=n3843 VSS=VSS
XU1667 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1263 A1=n1264 A3=n1262 Z=n1258
XU1666 FA1D0BWP7T $PINS CO=n1262 S=n1249 CI=n1255 B=n1256 VDD=VDD A=n1257
+ VSS=VSS
XU1663 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4810 ZN=n1254 A2=n4568
XU1662 INVD0BWP7T $PINS ZN=n2982 VSS=VSS VDD=VDD I=SA_core_shift_wire<91>
XU1661 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3774 ZN=n1268 A2=n4679
XU1659 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4563 ZN=n1269 A2=n3783
XU1658 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3777 ZN=n1270 A2=n4573
XU1657 INVD0BWP7T $PINS ZN=n1261 VSS=VSS VDD=VDD I=n1253
XU1656 FA1D0BWP7T $PINS CO=n1264 S=n1248 CI=n1250 B=n1251 VDD=VDD A=n1252
+ VSS=VSS
XU1655 MOAI22D0BWP7T $PINS A2=n3086 A1=n1249 ZN=SA_core_pe_3_2_N12 B1=n3084
+ VSS=VSS B2=SA_core_shift_wire<82> VDD=VDD
XU1654 INVD0BWP7T $PINS ZN=n1255 VSS=VSS VDD=VDD I=n1248
XU1653 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4569 ZN=n1250 A2=n3783
XU1652 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4629 ZN=n1251 A2=n4573
XU1650 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1253 A1=SA_core_shift_wire<90>
+ ZN=n1257 A2=n1244
XU1649 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<80>
+ A1=SA_core_connect<162> ZN=n1253 A3=SA_core_shift_wire<90>
XU1648 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3777 ZN=n1244 A2=n4679
XU1646 OAI22D1BWP7T $PINS B1=n4746 A2=n1243 ZN=SA_core_pe_3_2_N11 A1=n3086
+ VDD=VDD B2=n1359 VSS=VSS
XU1645 INVD1BWP7T $PINS ZN=n1359 VSS=VSS VDD=VDD I=SA_core_shift_wire<81>
XU1643 XNR3D0BWP7T $PINS A1=n1246 A2=n1247 VDD=VDD VSS=VSS A3=n1245 ZN=n1243
XU1642 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4573 ZN=n1245 A2=n3783
XU1641 INVD0BWP7T $PINS ZN=n1247 VSS=VSS VDD=VDD I=n1242
XU1639 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1252 A1=n4629 A3=n4525 A2=n4679
XU1637 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4810 ZN=n1241
+ A2=SA_core_connect<80>
XU1635 MOAI22D0BWP7T $PINS A2=n1240 A1=n3086 ZN=SA_core_pe_3_2_N10 B1=n3084
+ VSS=VSS B2=SA_core_shift_wire<80> VDD=VDD
XU1633 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1242 A1=SA_core_shift_wire<88>
+ ZN=n1240 A2=n1239
XU1632 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<80>
+ A1=SA_core_connect<160> ZN=n1242 A3=SA_core_shift_wire<88>
XU1631 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3783 ZN=n1239 A2=n4679
XU1628 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_2_N25 A2=n4731
+ A1=SA_core_connect<87>
XU1627 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_2_N24 A2=n4731 A1=n4554
XU1626 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N23 A2=n4557
XU1624 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N22 A2=n3829
XU1622 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N21 A2=n4563
XU1620 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N20 A2=n4569
XU1618 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_2_N19 A2=n4573
XU1614 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4743 A2=n1237 A1=n1238
+ ZN=SA_core_pe_0_0_N17 C=n1236
XU1613 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1238 ZN=n1236 A2=n1237
XU1612 XNR4D0BWP7T $PINS A1=n1213 A2=n1234 ZN=n1237 A3=n1233 A4=n1232 VDD=VDD
+ VSS=VSS
XU1611 XNR4D0BWP7T $PINS A1=n1231 A2=n1230 ZN=n1232 A3=n1229 A4=n1228 VDD=VDD
+ VSS=VSS
XU1610 XNR4D0BWP7T $PINS A1=n4533 A2=n1227 ZN=n1228 A3=n1226 A4=n1225 VDD=VDD
+ VSS=VSS
XU1608 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1223 A1=n4649 ZN=n1221 A2=n3874
XU1607 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4639 ZN=n1223 A2=n4652
XU1606 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_0<0> ZN=n1226 A2=n4511
XU1605 FA1D0BWP7T $PINS CO=n1227 S=n1200 CI=n1218 B=n1219 VDD=VDD A=n1220
+ VSS=VSS
XU1604 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1214 ZN=n1229 A3=n4664 A2=n1216
+ A1=n4519
XU1603 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1216 A1=n4519 ZN=n1214 A2=n4664
XU1602 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4520 ZN=n1216 A2=SA_col_0<6>
XU1601 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4514 ZN=n1230 A2=n4674
XU1600 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_0<3> ZN=n1231 A2=n4516
XU1599 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_0<1> ZN=n1234 A2=n4512
XU1597 FA1D0BWP7T $PINS CO=n1213 S=n1192 CI=n1210 B=n1211 VDD=VDD A=n4755
+ VSS=VSS
XU1596 XOR4D0BWP7T $PINS A3=n1207 VDD=VDD A4=n1206 VSS=VSS A1=n1196 A2=n1208
+ Z=n1238
XU1595 FA1D0BWP7T $PINS CO=n1206 S=n1202 CI=n1203 B=n1204 VDD=VDD A=n1205
+ VSS=VSS
XU1594 FA1D0BWP7T $PINS CO=n1207 S=n1195 CI=n1200 B=n1201 VDD=VDD A=n1202
+ VSS=VSS
XU1593 FA1D0BWP7T $PINS CO=n1208 S=n1194 CI=n1197 B=n1198 VDD=VDD A=n1199
+ VSS=VSS
XU1591 FA1D0BWP7T $PINS CO=n1196 S=n1211 CI=n1193 B=n1194 VDD=VDD A=n1195
+ VSS=VSS
XU1590 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_0_N16 A2=n4742 A1=n1192
XU1589 FA1D0BWP7T $PINS CO=n1210 S=n1166 CI=n1189 B=n1190 VDD=VDD A=n1191
+ VSS=VSS
XU1588 FA1D0BWP7T $PINS CO=n1193 S=n1190 CI=n1186 B=n1187 VDD=VDD A=n1188
+ VSS=VSS
XU1587 OA21D0BWP7T $PINS Z=n1197 A1=n4534 VDD=VDD A2=n1185 VSS=VSS B=n1233
XU1586 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4534 A1=SA_col_0<1> ZN=n1233
+ A3=n4514
XU1585 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4644 ZN=n1185 A2=n4515
XU1584 FA1D0BWP7T $PINS CO=n1198 S=n1188 CI=n1180 B=n1181 VDD=VDD A=n1182
+ VSS=VSS
XU1583 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4664 ZN=n1218 A2=n4649
XU1582 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4517 ZN=n1219 A2=n4675
XU1581 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3876 ZN=n1220 A2=n4519
XU1580 FA1D0BWP7T $PINS CO=n1201 S=n1191 CI=n1174 B=n1175 VDD=VDD A=n1176
+ VSS=VSS
XU1579 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3873 ZN=n1203 A2=n4640
XU1578 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4513 ZN=n1204 A2=n4635
XU1577 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4521 ZN=n1205 A2=n3874
XU1574 AOI21D0BWP7T $PINS VSS=VSS A2=n1164 VDD=VDD A1=n1167 B=n1163
+ ZN=SA_core_pe_0_0_N15
XU1573 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4742 A1=n1167 ZN=n1163 A2=n1164
XU1571 FA1D0BWP7T $PINS CO=n1165 S=n1150 CI=n1160 B=n1161 VDD=VDD A=n1162
+ VSS=VSS
XU1570 FA1D0BWP7T $PINS CO=n1189 S=n1160 CI=n1157 B=n1158 VDD=VDD A=n1159
+ VSS=VSS
XU1569 FA1D0BWP7T $PINS CO=n1186 S=n1162 CI=n1154 B=n1155 VDD=VDD A=n1156
+ VSS=VSS
XU1568 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1187 B=n1199 A2=n1153
+ A1=SA_core_shift_wire<5>
XU1567 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_0<1> VDD=VDD A2=n4516
+ A3=SA_core_shift_wire<5> Z=n1199
XU1566 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4644 ZN=n1153 A2=n4517
XU1565 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3874 ZN=n1180 A2=n4640
XU1564 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4664 ZN=n1181 A2=n4521
XU1563 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4515 ZN=n1182 A2=n4635
XU1562 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4519 ZN=n1174 A2=n4675
XU1786 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1408 A1=n4638 A3=n3843 A2=n3833
XU1785 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4822 ZN=n1372 A2=n4847
XU1784 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4589 ZN=n1387 A2=n4625
XU1782 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4565 ZN=n1388 A2=n4595
XU1781 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4591 ZN=n1389 A2=n3835
XU1780 INVD0BWP7T $PINS ZN=n1380 VSS=VSS VDD=VDD I=n1371
XU1779 FA1D0BWP7T $PINS CO=n1383 S=n1366 CI=n1368 B=n1369 VDD=VDD A=n1370
+ VSS=VSS
XU1778 MOAI22D0BWP7T $PINS A2=n3086 A1=n1367 ZN=SA_core_pe_3_1_N12 B1=n3084
+ VSS=VSS B2=SA_core_shift_wire<74> VDD=VDD
XU1777 INVD0BWP7T $PINS ZN=n1374 VSS=VSS VDD=VDD I=n1366
XU1776 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3833 ZN=n1368 A2=n4595
XU1775 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4638 ZN=n1369 A2=n3835
XU1773 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1371 A1=SA_core_shift_wire<82>
+ ZN=n1376 A2=n1362
XU1772 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4831 A1=n4590 ZN=n1371
+ A3=SA_core_shift_wire<82>
XU1771 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4591 ZN=n1362 A2=n4625
XU1769 OAI22D1BWP7T $PINS B1=n4746 A2=n1361 ZN=SA_core_pe_3_1_N11 A1=n3086
+ VDD=VDD B2=n1479 VSS=VSS
XU1767 XNR3D0BWP7T $PINS A1=n1364 A2=n1365 VDD=VDD VSS=VSS A3=n1363 ZN=n1361
XU1766 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3835 ZN=n1363 A2=n4595
XU1765 INVD0BWP7T $PINS ZN=n1365 VSS=VSS VDD=VDD I=n1360
XU1763 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1370 A1=n4638 A3=n1359 A2=n4625
XU1761 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4822 ZN=n1358 A2=n4831
XU1760 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1357 A1=n4746
+ ZN=SA_core_pe_3_1_N10 A2=n1477
XU1759 OAI211D0BWP7T $PINS A2=n1356 ZN=n1357 A1=SA_core_shift_wire<80> B=n4749
+ VDD=VDD C=n1360 VSS=VSS
XU1758 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4831 A1=n4594 ZN=n1360
+ A3=SA_core_shift_wire<80>
XU1757 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4595 ZN=n1356 A2=n4625
XU1754 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_1_N25 A2=n4729
+ A1=SA_core_connect<79>
XU1753 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_1_N24 A2=n4729
+ A1=SA_core_connect<78>
XU1751 INVD0BWP7T $PINS ZN=n1417 VSS=VSS VDD=VDD I=SA_core_connect<77>
XU1750 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N22 A2=n4559
XU1748 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N21 A2=n4565
XU1746 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N20 A2=n3833
XU1744 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N19 A2=n3835
XU1742 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_1_N18 A2=n4625
XU1739 XNR4D0BWP7T $PINS A1=n1353 A2=n1352 ZN=n1354 A3=n1351 A4=n1350 VDD=VDD
+ VSS=VSS
XU1738 XNR4D0BWP7T $PINS A1=n1349 A2=n1348 ZN=n1350 A3=n1347 A4=n1346 VDD=VDD
+ VSS=VSS
XU1737 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4810 ZN=n1347 A2=n4554
XU1736 XOR4D0BWP7T $PINS A3=n1343 VDD=VDD A4=n1342 VSS=VSS A1=n1345 A2=n1344
+ Z=n1348
XU1735 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<166> ZN=n1342
+ A2=n4572
XU1734 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4832 ZN=n1343
+ A2=SA_core_connect<162>
XU1733 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<164> ZN=n1344
+ A2=n4562
XU1732 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<163> ZN=n1345
+ A2=SA_core_connect<84>
XU1731 FA1D0BWP7T $PINS CO=n1349 S=n1321 CI=n1339 B=n1340 VDD=VDD A=n1341
+ VSS=VSS
XU1730 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<165> ZN=n1351
+ A2=n4568
XU1729 XOR4D0BWP7T $PINS A3=n1337 VDD=VDD A4=n1336 VSS=VSS
+ A1=SA_core_shift_wire<95> A2=n1338 Z=n1352
XU1728 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<80> ZN=n1336
+ A2=SA_core_connect<167>
XU1727 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<160> ZN=n1337
+ A2=SA_core_connect<87>
XU1726 FA1D0BWP7T $PINS CO=n1338 S=n1320 CI=n1333 B=n1334 VDD=VDD A=n1335
+ VSS=VSS
XU1725 XOR4D0BWP7T $PINS A3=n1330 VDD=VDD A4=n1329 VSS=VSS A1=n1318 A2=n1322
+ Z=n1353
XU1724 FA1D0BWP7T $PINS CO=n1329 S=n1333 CI=n1326 B=n1327 VDD=VDD A=n1328
+ VSS=VSS
XU1723 FA1D0BWP7T $PINS CO=n1330 S=n1335 CI=n1323 B=n1324 VDD=VDD A=n1325
+ VSS=VSS
XU1721 FA1D0BWP7T $PINS CO=n1322 S=n1316 CI=n1319 B=n1320 VDD=VDD A=n1321
+ VSS=VSS
XU1719 FA1D0BWP7T $PINS CO=n1318 S=n1314 CI=n1315 B=n1316 VDD=VDD A=n1317
+ VSS=VSS
XU1718 AO22D0BWP7T $PINS Z=SA_core_pe_3_2_N16 A2=n1314 A1=n4749 B1=n3084
+ VDD=VDD B2=SA_core_shift_wire<86> VSS=VSS
XU1717 FA1D0BWP7T $PINS CO=n1315 S=n1291 CI=n1311 B=n1312 VDD=VDD A=n1313
+ VSS=VSS
XU1716 FA1D0BWP7T $PINS CO=n1319 S=n1313 CI=n1308 B=n1309 VDD=VDD A=n1310
+ VSS=VSS
XU1715 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1326 A2=SA_core_connect<80>
+ A1=SA_core_connect<166>
XU1714 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1327 A2=SA_core_connect<160>
+ A1=n4554
XU1713 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1328 A2=n4572
+ A1=SA_core_connect<165>
XU1712 FA1D0BWP7T $PINS CO=n1334 S=n1312 CI=n1305 B=n1306 VDD=VDD A=n1307
+ VSS=VSS
XU1711 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3771 ZN=n1323 A2=n4569
XU1710 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3829 ZN=n1324 A2=n3777
XU1709 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3774 ZN=n1325 A2=n4563
XU1708 OA21D0BWP7T $PINS Z=n1339 A1=n4835 VDD=VDD A2=n1298 VSS=VSS B=n1346
XU1707 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4835 A1=n4810 ZN=n1346 A3=n4832
XU1706 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4629 ZN=n1298 A2=n4557
XU1705 FA1D0BWP7T $PINS CO=n1341 S=n1309 CI=n1293 B=n1294 VDD=VDD A=n1295
+ VSS=VSS
XU1704 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1290 ZN=n1317 A2=n1291 A1=n1292
XU1703 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1289 A1=n1291 ZN=n1290 A2=n1292
XU1702 OAI22D1BWP7T $PINS B1=n4746 A2=n1288 ZN=SA_core_pe_3_2_N15 A1=n3086
+ VDD=VDD B2=n1400 VSS=VSS
XU1701 INVD1BWP7T $PINS ZN=n1400 VSS=VSS VDD=VDD I=SA_core_shift_wire<85>
XU1700 XNR3D0BWP7T $PINS A1=n1289 A2=n1292 VDD=VDD VSS=VSS A3=n1291 ZN=n1288
XU1699 FA1D0BWP7T $PINS CO=n1311 S=n1276 CI=n1285 B=n4809 VDD=VDD A=n1287
+ VSS=VSS
XU1698 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4563 ZN=n1305 A2=n3777
XU1697 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3774 ZN=n1306 A2=n4569
XU1696 FA1D0BWP7T $PINS CO=n1308 S=n1278 CI=n1282 B=n1283 VDD=VDD A=n1284
+ VSS=VSS
XU1695 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1293 A2=SA_core_connect<80>
+ A1=SA_core_connect<165>
XU1694 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3771 ZN=n1294 A2=n4573
XU1693 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4557 ZN=n1295 A2=n3783
XU1692 AOI21D0BWP7T $PINS VSS=VSS A2=n1279 VDD=VDD A1=n4523 B=n1340 ZN=n1310
XU1690 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4810 ZN=n1279
+ A2=SA_core_connect<84>
XU1688 FA1D0BWP7T $PINS CO=n1292 S=n1273 CI=n1276 B=n1277 VDD=VDD A=n1278
+ VSS=VSS
XU1687 FA1D0BWP7T $PINS CO=n1289 S=n1272 CI=n1273 B=n3991 VDD=VDD A=n1275
+ VSS=VSS
XU1686 MOAI22D0BWP7T $PINS A2=n3841 A1=n4746 ZN=SA_core_pe_3_2_N14 B1=n4749
+ VSS=VSS B2=n1272 VDD=VDD
XU1685 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3774 ZN=n1285 A2=n4573
XU1683 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1307 A1=n4629 A3=n3000 A2=n4563
XU1682 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4810 ZN=n1271 A2=n4562
XU1896 FA1D0BWP7T $PINS CO=n1506 S=n1487 CI=n1488 B=n1489 VDD=VDD A=n1490
+ VSS=VSS
XU1895 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1487 ZN=SA_core_pe_3_0_N12 A2=n3086
XU1894 INVD0BWP7T $PINS ZN=n1488 VSS=VSS VDD=VDD I=n1486
XU1893 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3870 ZN=n1494 A2=n3816
XU1892 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4671 ZN=n1495 A2=n3871
XU1890 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1491 A1=SA_core_shift_wire<74>
+ ZN=n1490 A2=n1482
XU1889 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4668 A1=SA_core_connect<114>
+ ZN=n1491 A3=SA_core_shift_wire<74>
XU1888 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3812 ZN=n1482 A2=n4669
XU1886 AOI21D0BWP7T $PINS VSS=VSS A2=n1481 VDD=VDD A1=n1484 B=n1480
+ ZN=SA_core_pe_3_0_N11
XU1885 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4749 A1=n1484 ZN=n1480 A2=n1481
XU1883 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3871 ZN=n1483 A2=n3816
XU1879 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4842 ZN=n1478 A2=n4668
XU1875 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4836 ZN=n1476 A2=n4668
XU1874 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_0_N25 A2=n4729
+ A1=SA_row_3<7>
XU1873 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N24 A2=n1536
XU1871 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N23 A2=n3867
XU1869 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N22 A2=n3868
XU1867 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N21 A2=n3869
XU1863 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_3_0_N19 A2=n3871
XU1858 XNR4D0BWP7T $PINS A1=n1474 A2=n1473 ZN=n1475 A3=n1472 A4=n1471 VDD=VDD
+ VSS=VSS
XU1857 XNR4D0BWP7T $PINS A1=n1470 A2=n1469 ZN=n1471 A3=n1468 A4=n1467 VDD=VDD
+ VSS=VSS
XU1856 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4822 ZN=n1468
+ A2=SA_core_connect<78>
XU1855 XOR4D0BWP7T $PINS A3=n1464 VDD=VDD A4=n1463 VSS=VSS A1=n1466 A2=n1465
+ Z=n1469
XU1854 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<142> ZN=n1463
+ A2=SA_core_connect<73>
XU1853 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<77> ZN=n1464
+ A2=n4590
XU1852 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<140> ZN=n1465
+ A2=n4564
XU1851 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4588 ZN=n1466
+ A2=SA_core_connect<76>
XU1850 FA1D0BWP7T $PINS CO=n1470 S=n1438 CI=n1460 B=n1461 VDD=VDD A=n1462
+ VSS=VSS
XU1849 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4843 ZN=n1472 A2=n4847
XU1848 XOR4D0BWP7T $PINS A3=n1457 VDD=VDD A4=n1456 VSS=VSS A1=n1459 A2=n1455
+ Z=n1473
XU1847 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4831 ZN=n1456
+ A2=SA_core_connect<143>
XU1846 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4594 ZN=n1457
+ A2=SA_core_connect<79>
XU1844 FA1D0BWP7T $PINS CO=n1455 S=n1435 CI=n1452 B=n1453 VDD=VDD A=n1454
+ VSS=VSS
XU1843 FA1D0BWP7T $PINS CO=n1459 S=n1437 CI=n1449 B=n1450 VDD=VDD A=n1451
+ VSS=VSS
XU1842 XOR4D0BWP7T $PINS A3=n1447 VDD=VDD A4=n1446 VSS=VSS
+ A1=SA_core_shift_wire<87> A2=n1439 Z=n1474
XU1841 FA1D0BWP7T $PINS CO=n1446 S=n1449 CI=n1443 B=n1444 VDD=VDD A=n1445
+ VSS=VSS
XU1840 FA1D0BWP7T $PINS CO=n1447 S=n1451 CI=n1440 B=n1441 VDD=VDD A=n1442
+ VSS=VSS
XU1838 FA1D0BWP7T $PINS CO=n1439 S=n1453 CI=n1436 B=n1437 VDD=VDD A=n1438
+ VSS=VSS
XU1837 AO22D0BWP7T $PINS Z=SA_core_pe_3_1_N16 A2=n1435 A1=n4749 B1=n3084
+ VDD=VDD B2=SA_core_shift_wire<78> VSS=VSS
XU1836 FA1D0BWP7T $PINS CO=n1452 S=n1412 CI=n1432 B=n1433 VDD=VDD A=n1434
+ VSS=VSS
XU1835 FA1D0BWP7T $PINS CO=n1436 S=n1434 CI=n1429 B=n1430 VDD=VDD A=n1431
+ VSS=VSS
XU1834 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1443 A2=n4831
+ A1=SA_core_connect<142>
XU1833 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1444 A2=n4594 A1=SA_core_connect<78>
XU1832 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1445 A2=SA_core_connect<73> A1=n4843
XU1831 FA1D0BWP7T $PINS CO=n1450 S=n1433 CI=n1426 B=n1427 VDD=VDD A=n4771
+ VSS=VSS
XU1830 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1425 ZN=n1440 A2=n3833
XU1829 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4559 ZN=n1441 A2=n4591
XU1828 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4589 ZN=n1442 A2=n4565
XU1827 OA21D0BWP7T $PINS Z=n1460 A1=n1419 VDD=VDD A2=SA_core_shift_wire<86>
+ VSS=VSS B=n1467
XU1826 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<77> A1=n4822
+ ZN=n1467 A3=SA_core_shift_wire<86>
XU1825 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4638 ZN=n1419 A2=n1417
XU1824 FA1D0BWP7T $PINS CO=n1462 S=n1430 CI=n1414 B=n1415 VDD=VDD A=n1416
+ VSS=VSS
XU1823 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1411 ZN=n1454 A2=n1412 A1=n1413
XU1822 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1410 A1=n1412 ZN=n1411 A2=n1413
XU1821 OAI22D1BWP7T $PINS B1=n4746 A2=n1409 ZN=SA_core_pe_3_1_N15 A1=n3086
+ VDD=VDD B2=n4524 VSS=VSS
XU1819 XNR3D0BWP7T $PINS A1=n1410 A2=n1413 VDD=VDD VSS=VSS A3=n1412 ZN=n1409
XU1818 FA1D0BWP7T $PINS CO=n1432 S=n1396 CI=n1406 B=n4252 VDD=VDD A=n4823
+ VSS=VSS
XU1817 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4565 ZN=n1426 A2=n4591
XU1816 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4589 ZN=n1427 A2=n3833
XU1815 FA1D0BWP7T $PINS CO=n1429 S=n1398 CI=n1403 B=n1404 VDD=VDD A=n1405
+ VSS=VSS
XU1814 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1414 A2=n4831 A1=n4843
XU1813 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1425 ZN=n1415 A2=n3835
XU1812 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1417 ZN=n1416 A2=n4595
XU1811 AOI21D1BWP7T $PINS VSS=VSS A2=n1399 VDD=VDD A1=n1400 B=n1461 ZN=n1431
XU1810 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1461 A1=n4638 A3=n1400 A2=n4559
XU1809 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4822 ZN=n1399
+ A2=SA_core_connect<76>
XU1808 FA1D0BWP7T $PINS CO=n1413 S=n1393 CI=n1396 B=n1397 VDD=VDD A=n1398
+ VSS=VSS
XU1807 FA1D0BWP7T $PINS CO=n1410 S=n1392 CI=n1393 B=n3990 VDD=VDD A=n1395
+ VSS=VSS
XU1806 MOAI22D0BWP7T $PINS A2=n1512 A1=n4746 ZN=SA_core_pe_3_1_N14 B1=n4749
+ VSS=VSS B2=n1392 VDD=VDD
XU1805 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4589 ZN=n1406 A2=n3835
XU1803 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1428 A1=n4638 A3=n3841 A2=n4565
XU1802 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4822 ZN=n1390 A2=n4564
XU1801 FA1D0BWP7T $PINS CO=n1397 S=n1379 CI=n1387 B=n1388 VDD=VDD A=n1389
+ VSS=VSS
XU1800 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1425 ZN=n1403 A2=n4625
XU1798 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4591 ZN=n1404 A2=n3833
XU1797 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4559 ZN=n1405 A2=n4595
XU1795 MAOI222D1BWP7T $PINS ZN=n1385 C=n1382 B=n1383 VDD=VDD A=n1384 VSS=VSS
XU1794 INVD0BWP7T $PINS ZN=n1384 VSS=VSS VDD=VDD I=n1381
XU1793 FA1D0BWP7T $PINS CO=n1395 S=n1382 CI=n1378 B=n1379 VDD=VDD A=n1380
+ VSS=VSS
XU1792 INVD1BWP7T $PINS ZN=n1512 VSS=VSS VDD=VDD I=SA_core_shift_wire<76>
XU1791 OAI22D2BWP7T $PINS B1=n4746 A2=n3086 ZN=SA_core_pe_3_1_N13 A1=n1377
+ VDD=VDD B2=n1493 VSS=VSS
XU1790 INVD0BWP7T $PINS ZN=n1493 VSS=VSS VDD=VDD I=SA_core_shift_wire<75>
XU1789 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1382 A1=n1383 A3=n1381 Z=n1377
XU1788 FA1D0BWP7T $PINS CO=n1381 S=n1367 CI=n1374 B=n1375 VDD=VDD A=n1376
+ VSS=VSS
XU2014 XNR3D0BWP7T $PINS A1=n1615 A2=n1616 VDD=VDD VSS=VSS A3=n1614 ZN=n1612
XU2013 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3823 ZN=n1614 A2=n4684
XU2007 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4688 ZN=n1609
+ A2=SA_core_connect<64>
XU2006 MOAI22D0BWP7T $PINS A2=n1607 A1=n4470 ZN=SA_core_pe_2_3_N10 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<64> VDD=VDD
XU2002 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1610 A1=n1604 ZN=n1607
+ A2=SA_core_output_row_2<0>
XU2001 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<64>
+ A1=SA_core_connect<176> ZN=n1610 A3=SA_core_output_row_2<0>
XU2000 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4684 ZN=n1604 A2=n4648
XU1996 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_3_N33 A2=n4729
+ A1=SA_core_connect<183>
XU1995 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_3_N32 A2=n4729 A1=n4604
XU1994 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N31 A2=n1678
XU1993 INVD1BWP7T $PINS ZN=n1678 VSS=VSS VDD=VDD I=SA_core_connect<181>
XU1992 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N30 A2=n1674
XU1990 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N29 A2=n3789
XU1986 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N28 A2=n4606
XU1981 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N27 A2=n4689
XU1979 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_3_N26 A2=n4684
XU1976 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1600 ZN=n1598 A2=n1599
XU1975 XNR4D0BWP7T $PINS A1=n1570 A2=n1596 ZN=n1599 A3=n1595 A4=n1594 VDD=VDD
+ VSS=VSS
XU1974 XNR4D0BWP7T $PINS A1=n1593 A2=n1592 ZN=n1594 A3=n1591 A4=n1590 VDD=VDD
+ VSS=VSS
XU1973 XNR4D0BWP7T $PINS A1=n1589 A2=n1585 ZN=n1590 A3=n1587 A4=n1586 VDD=VDD
+ VSS=VSS
XU1972 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4668 ZN=n1586
+ A2=SA_core_connect<119>
XU1971 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_3<7> ZN=n1587 A2=n4836
XU1969 FA1D0BWP7T $PINS CO=n1585 S=n1568 CI=n1582 B=n1583 VDD=VDD A=n1584
+ VSS=VSS
XU1968 FA1D0BWP7T $PINS CO=n1589 S=n1558 CI=n1579 B=n1580 VDD=VDD A=n1581
+ VSS=VSS
XU1967 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_3<2> ZN=n1591
+ A2=SA_core_connect<117>
XU1965 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1577 A1=n3810 ZN=n1575 A2=n3868
XU1964 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<116> ZN=n1577
+ A2=SA_row_3<3>
XU1962 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1573 A1=n3812 ZN=n1571 A2=n3867
XU1961 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<118> ZN=n1573
+ A2=SA_row_3<1>
XU1960 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_3<6> ZN=n1596 A2=n4842
XU1958 FA1D0BWP7T $PINS CO=n1570 S=n1554 CI=n1567 B=n1568 VDD=VDD A=n3994
+ VSS=VSS
XU1957 XOR4D0BWP7T $PINS A3=n1565 VDD=VDD A4=n1564 VSS=VSS A1=n4834 A2=n1566
+ Z=n1600
XU1956 FA1D0BWP7T $PINS CO=n1564 S=n1560 CI=n1561 B=n1562 VDD=VDD A=n1563
+ VSS=VSS
XU1955 FA1D0BWP7T $PINS CO=n1565 S=n1584 CI=n1558 B=n1559 VDD=VDD A=n1560
+ VSS=VSS
XU1954 FA1D0BWP7T $PINS CO=n1566 S=n1583 CI=n1555 B=n1556 VDD=VDD A=n1557
+ VSS=VSS
XU1953 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_0_N16 A2=n4749 A1=n1554
XU1952 FA1D0BWP7T $PINS CO=n1567 S=n1532 CI=n1551 B=n1552 VDD=VDD A=n1553
+ VSS=VSS
XU1951 FA1D0BWP7T $PINS CO=n1582 S=n1552 CI=n1548 B=n1549 VDD=VDD A=n1550
+ VSS=VSS
XU1950 OA21D0BWP7T $PINS Z=n1555 A1=n1547 VDD=VDD A2=SA_core_shift_wire<78>
+ VSS=VSS B=n1595
XU1949 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_row_3<5> A1=n4842 ZN=n1595
+ A3=SA_core_shift_wire<78>
XU1948 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4671 ZN=n1547 A2=n3867
XU1947 FA1D0BWP7T $PINS CO=n1556 S=n1550 CI=n1543 B=n1544 VDD=VDD A=n1545
+ VSS=VSS
XU1946 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1542 ZN=n1579 A2=n3870
XU1945 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3868 ZN=n1580 A2=n3812
XU1944 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3810 ZN=n1581 A2=n3869
XU1943 FA1D0BWP7T $PINS CO=n1559 S=n1553 CI=n1537 B=n1538 VDD=VDD A=n1539
+ VSS=VSS
XU1942 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1561 A2=n4668
+ A1=SA_core_connect<118>
XU1941 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1536 ZN=n1562 A2=n3816
XU1940 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1563 A2=SA_row_3<1>
+ A1=SA_core_connect<117>
XU1937 AOI21D0BWP7T $PINS VSS=VSS A2=n1530 VDD=VDD A1=n1533 B=n1529
+ ZN=SA_core_pe_3_0_N15
XU1936 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4749 A1=n1533 ZN=n1529 A2=n1530
XU1935 MAOI22D0BWP7T $PINS A2=n1531 ZN=n1530 A1=n1532 B2=n1532 VDD=VDD B1=n1531
+ VSS=VSS
XU1934 FA1D0BWP7T $PINS CO=n1531 S=n1514 CI=n1526 B=n1527 VDD=VDD A=n1528
+ VSS=VSS
XU1933 FA1D0BWP7T $PINS CO=n1551 S=n1526 CI=n1523 B=n1524 VDD=VDD A=n4827
+ VSS=VSS
XU1932 FA1D0BWP7T $PINS CO=n1548 S=n1528 CI=n1520 B=n1521 VDD=VDD A=n1522
+ VSS=VSS
XU1929 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4842 ZN=n1518 A2=SA_row_3<4>
XU1928 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1543 A2=n4668
+ A1=SA_core_connect<117>
XU1927 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1542 ZN=n1544 A2=n3871
XU1926 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3867 ZN=n1545 A2=n3816
XU1925 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3869 ZN=n1537 A2=n3812
XU1924 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3810 ZN=n1538 A2=n3870
XU1923 FA1D0BWP7T $PINS CO=n1533 S=n1513 CI=n1514 B=n1515 VDD=VDD A=n1516
+ VSS=VSS
XU1922 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_3_0_N14 A2=n4749 A1=n1513
XU1921 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3810 ZN=n1523 A2=n3871
XU1918 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4842 ZN=n1511 A2=SA_row_3<3>
XU1917 FA1D0BWP7T $PINS CO=n1527 S=n1502 CI=n1508 B=n1509 VDD=VDD A=n1510
+ VSS=VSS
XU1916 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1542 ZN=n1520 A2=n4669
XU1915 INVD0BWP7T $PINS ZN=n1542 VSS=VSS VDD=VDD I=SA_core_connect<116>
XU1914 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3812 ZN=n1521 A2=n3870
XU1913 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3868 ZN=n1522 A2=n3816
XU1912 MAOI222D2BWP7T $PINS ZN=n1515 C=n1504 B=n1505 VDD=VDD A=n1506 VSS=VSS
XU1911 FA1D0BWP7T $PINS CO=n1516 S=n1498 CI=n1501 B=n1502 VDD=VDD A=n1503
+ VSS=VSS
XU1910 AOI21D0BWP7T $PINS VSS=VSS A2=n1500 VDD=VDD A1=n1506 B=n1499
+ ZN=SA_core_pe_3_0_N13
XU1909 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4749 A1=n1506 ZN=n1499 A2=n1500
XU1908 AOI22D1BWP7T $PINS B1=n1497 A2=n1504 ZN=n1500 A1=n1498 VDD=VDD B2=n1505
+ VSS=VSS
XU1907 INVD0BWP7T $PINS ZN=n1505 VSS=VSS VDD=VDD I=n1498
XU1906 INVD0BWP7T $PINS ZN=n1504 VSS=VSS VDD=VDD I=n1497
XU1905 FA1D0BWP7T $PINS CO=n1497 S=n1486 CI=n1494 B=n1495 VDD=VDD A=n1496
+ VSS=VSS
XU1904 AOI21D0BWP7T $PINS VSS=VSS A2=n1492 VDD=VDD A1=n1493 B=n4827 ZN=n1501
XU1903 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1525 A1=n4671 A3=n1493 A2=n3870
XU1902 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4842 ZN=n1492 A2=SA_row_3<2>
XU1901 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3810 ZN=n1508 A2=n4669
XU1899 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3869 ZN=n1509 A2=n3816
XU1898 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3812 ZN=n1510 A2=n3871
XU1897 INVD0BWP7T $PINS ZN=n1503 VSS=VSS VDD=VDD I=n1491
XU2120 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_2_N33 A2=n4731
+ A1=SA_core_connect<159>
XU2119 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_2_N32 A2=n4731
+ A1=SA_core_connect<158>
XU2118 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N31 A2=n1798
XU2116 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N30
+ A2=n3772
XU2114 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N29 A2=n3775
XU2112 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N28
+ A2=n4600
XU2110 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N27 A2=n4667
XU2108 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N26 A2=n4602
XU2106 IOA22D2BWP7T $PINS A2=SA_core_shift_wire<71> A1=n1606
+ ZN=SA_core_pe_2_3_N17 B1=n4470 VSS=VSS B2=n1726 VDD=VDD
XU2105 XNR4D0BWP7T $PINS A1=n1725 A2=n1724 ZN=n1726 A3=n1723 A4=n1722 VDD=VDD
+ VSS=VSS
XU2104 XNR4D0BWP7T $PINS A1=n1721 A2=n1720 ZN=n1722 A3=n1719 A4=n1718 VDD=VDD
+ VSS=VSS
XU2103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4688 ZN=n1719
+ A2=SA_core_connect<70>
XU2102 XOR4D0BWP7T $PINS A3=n1715 VDD=VDD A4=n1714 VSS=VSS A1=n1717 A2=n1716
+ Z=n1720
XU2101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4604 ZN=n1714
+ A2=SA_core_connect<65>
XU2100 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4540 ZN=n1715 A2=n4605
XU2099 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<180> ZN=n1716
+ A2=SA_core_connect<67>
XU2098 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<179> ZN=n1717
+ A2=SA_core_connect<68>
XU2097 FA1D0BWP7T $PINS CO=n1721 S=n1689 CI=n1711 B=n1712 VDD=VDD A=n1713
+ VSS=VSS
XU2096 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<181> ZN=n1723
+ A2=n4845
XU2095 XOR4D0BWP7T $PINS A3=n1708 VDD=VDD A4=n1707 VSS=VSS A1=n1710 A2=n1706
+ Z=n1724
XU2094 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<64> ZN=n1707
+ A2=SA_core_connect<183>
XU2093 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<176> ZN=n1708
+ A2=SA_core_connect<71>
XU2091 FA1D0BWP7T $PINS CO=n1706 S=n1686 CI=n1703 B=n1704 VDD=VDD A=n1705
+ VSS=VSS
XU2090 FA1D0BWP7T $PINS CO=n1710 S=n1688 CI=n1700 B=n1701 VDD=VDD A=n1702
+ VSS=VSS
XU2089 XOR4D0BWP7T $PINS A3=n1698 VDD=VDD A4=n1697 VSS=VSS A1=n1690
+ A2=SA_core_output_row_2<7> Z=n1725
XU2088 FA1D0BWP7T $PINS CO=n1697 S=n1700 CI=n1694 B=n1695 VDD=VDD A=n1696
+ VSS=VSS
XU2087 FA1D0BWP7T $PINS CO=n1698 S=n1702 CI=n1691 B=n1692 VDD=VDD A=n1693
+ VSS=VSS
XU2085 FA1D0BWP7T $PINS CO=n1690 S=n1704 CI=n1687 B=n1688 VDD=VDD A=n1689
+ VSS=VSS
XU2084 AO22D0BWP7T $PINS Z=SA_core_pe_2_3_N16 A2=n1686 A1=n4747 B1=n1606
+ VDD=VDD B2=n4812 VSS=VSS
XU2083 FA1D0BWP7T $PINS CO=n1703 S=n1663 CI=n1683 B=n1684 VDD=VDD A=n1685
+ VSS=VSS
XU2082 FA1D0BWP7T $PINS CO=n1687 S=n1685 CI=n1680 B=n1681 VDD=VDD A=n1682
+ VSS=VSS
XU2081 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1694 A2=SA_core_connect<64> A1=n4604
XU2080 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1695 A2=SA_core_connect<176>
+ A1=SA_core_connect<70>
XU2079 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3823 ZN=n1696 A2=n1678
XU2078 FA1D0BWP7T $PINS CO=n1701 S=n1684 CI=n1675 B=n1676 VDD=VDD A=n1677
+ VSS=VSS
XU2077 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1674 ZN=n1691 A2=n1673
XU2076 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1672 ZN=n1692 A2=n4606
XU2075 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3789 ZN=n1693 A2=n1669
XU2074 OA21D0BWP7T $PINS Z=n1711 A1=n1668 VDD=VDD A2=SA_core_output_row_2<6>
+ VSS=VSS B=n1718
XU2073 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4540 A1=n4688 ZN=n1718
+ A3=SA_core_output_row_2<6>
XU2072 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1668 A2=n4688 A1=n4540
XU2071 FA1D0BWP7T $PINS CO=n1713 S=n1681 CI=n1665 B=n1666 VDD=VDD A=n1667
+ VSS=VSS
XU2070 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1662 ZN=n1705 A2=n1663 A1=n1664
XU2069 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1661 A1=n1663 ZN=n1662 A2=n1664
XU2068 MOAI22D1BWP7T $PINS A2=n1660 A1=n4470 ZN=SA_core_pe_2_3_N15 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<69> VDD=VDD
XU2067 XNR3D0BWP7T $PINS A1=n1661 A2=n1664 VDD=VDD VSS=VSS A3=n1663 ZN=n1660
XU2066 FA1D0BWP7T $PINS CO=n1683 S=n1647 CI=n1657 B=n1658 VDD=VDD A=n1659
+ VSS=VSS
XU2065 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1669 ZN=n1675 A2=n4606
XU2064 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3789 ZN=n1676 A2=n1673
XU2063 FA1D0BWP7T $PINS CO=n1680 S=n1649 CI=n1654 B=n1655 VDD=VDD A=n1656
+ VSS=VSS
XU2062 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1678 ZN=n1665 A2=n4648
XU2061 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1674 ZN=n1666 A2=n3823
XU2060 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1667 A2=SA_core_connect<176>
+ A1=n4540
XU2059 AOI21D0BWP7T $PINS VSS=VSS A2=n1651 VDD=VDD A1=n1652 B=n1712 ZN=n1682
XU2057 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4688 ZN=n1651
+ A2=SA_core_connect<68>
XU2056 INVD0BWP7T $PINS ZN=n1652 VSS=VSS VDD=VDD I=SA_core_output_row_2<5>
XU2055 FA1D0BWP7T $PINS CO=n1664 S=n1644 CI=n1647 B=n1648 VDD=VDD A=n1649
+ VSS=VSS
XU2054 FA1D0BWP7T $PINS CO=n1661 S=n1643 CI=n1644 B=n3989 VDD=VDD A=n1646
+ VSS=VSS
XU2053 AO22D0BWP7T $PINS Z=SA_core_pe_2_3_N14 A2=n1643 A1=n4747 B1=n1606
+ VDD=VDD B2=SA_core_shift_wire<68> VSS=VSS
XU2052 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3789 ZN=n1657 A2=n3823
XU2050 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1677 A1=n4689 A3=n1642 A2=n1669
XU2049 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4688 ZN=n1641
+ A2=SA_core_connect<67>
XU2048 INVD0BWP7T $PINS ZN=n1642 VSS=VSS VDD=VDD I=SA_core_output_row_2<4>
XU2047 FA1D0BWP7T $PINS CO=n1648 S=n1630 CI=n1638 B=n1639 VDD=VDD A=n1640
+ VSS=VSS
XU2046 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1674 ZN=n1654 A2=n4648
XU2045 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4606 ZN=n1655 A2=n1673
XU2044 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1672 ZN=n1656 A2=n4684
XU2043 INVD0BWP7T $PINS ZN=n1672 VSS=VSS VDD=VDD I=SA_core_connect<68>
XU2040 INVD0BWP7T $PINS ZN=n1635 VSS=VSS VDD=VDD I=n1632
XU2039 FA1D0BWP7T $PINS CO=n1646 S=n1633 CI=n1629 B=n1630 VDD=VDD A=n1631
+ VSS=VSS
XU2038 MOAI22D0BWP7T $PINS A2=n4470 A1=n1628 ZN=SA_core_pe_2_3_N13 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<67> VDD=VDD
XU2037 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1633 A1=n1634 A3=n1632 Z=n1628
XU2036 FA1D0BWP7T $PINS CO=n1632 S=n1618 CI=n1625 B=n4227 VDD=VDD A=n1627
+ VSS=VSS
XU2034 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1659 A1=n4689 A3=n1624 A2=n1673
XU2033 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4688 ZN=n1623 A2=n4845
XU2032 INVD0BWP7T $PINS ZN=n1624 VSS=VSS VDD=VDD I=SA_core_output_row_2<3>
XU2031 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3789 ZN=n1638 A2=n4648
XU2030 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1669 ZN=n1639 A2=n4684
XU2029 INVD1BWP7T $PINS ZN=n1669 VSS=VSS VDD=VDD I=SA_core_connect<67>
XU2028 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4606 ZN=n1640 A2=n3823
XU2027 INVD0BWP7T $PINS ZN=n1631 VSS=VSS VDD=VDD I=n1622
XU2026 FA1D0BWP7T $PINS CO=n1634 S=n1617 CI=n1619 B=n1620 VDD=VDD A=n1621
+ VSS=VSS
XU2025 MOAI22D0BWP7T $PINS A2=n4470 A1=n1618 ZN=SA_core_pe_2_3_N12 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<66> VDD=VDD
XU2024 INVD0BWP7T $PINS ZN=n1625 VSS=VSS VDD=VDD I=n1617
XU2023 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1673 ZN=n1619 A2=n4684
XU2021 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4689 ZN=n1620 A2=n3823
XU2018 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<64> A1=n4605
+ ZN=n1622 A3=SA_core_output_row_2<2>
XU2017 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4606 ZN=n1613 A2=n4648
XU2016 MOAI22D0BWP7T $PINS A2=n1612 A1=n4470 ZN=SA_core_pe_2_3_N11 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<65> VDD=VDD
XU2227 XOR4D0BWP7T $PINS A3=n1835 VDD=VDD A4=n1834 VSS=VSS A1=n1837 A2=n1836
+ Z=n1840
XU2226 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<158> ZN=n1834
+ A2=n4549
XU2225 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4846 ZN=n1835 A2=n4599
XU2224 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<156> ZN=n1836
+ A2=SA_core_connect<59>
XU2223 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<155> ZN=n1837
+ A2=n4543
XU2222 FA1D0BWP7T $PINS CO=n1841 S=n1809 CI=n1831 B=n1832 VDD=VDD A=n1833
+ VSS=VSS
XU2221 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<157> ZN=n1843
+ A2=n4547
XU2220 XOR4D0BWP7T $PINS A3=n1828 VDD=VDD A4=n1827 VSS=VSS A1=n1830 A2=n1826
+ Z=n1844
XU2219 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<56> ZN=n1827
+ A2=SA_core_connect<159>
XU2218 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4601 ZN=n1828
+ A2=SA_core_connect<63>
XU2216 FA1D0BWP7T $PINS CO=n1826 S=n1806 CI=n1823 B=n1824 VDD=VDD A=n1825
+ VSS=VSS
XU2215 FA1D0BWP7T $PINS CO=n1830 S=n1808 CI=n1820 B=n1821 VDD=VDD A=n1822
+ VSS=VSS
XU2214 XOR4D0BWP7T $PINS A3=n1818 VDD=VDD A4=n1817 VSS=VSS
+ A1=SA_core_shift_wire<71> A2=n1810 Z=n1845
XU2213 FA1D0BWP7T $PINS CO=n1817 S=n1820 CI=n1814 B=n1815 VDD=VDD A=n1816
+ VSS=VSS
XU2212 FA1D0BWP7T $PINS CO=n1818 S=n1822 CI=n1811 B=n1812 VDD=VDD A=n1813
+ VSS=VSS
XU2210 FA1D0BWP7T $PINS CO=n1810 S=n1824 CI=n1807 B=n1808 VDD=VDD A=n1809
+ VSS=VSS
XU2209 AO22D0BWP7T $PINS Z=SA_core_pe_2_2_N16 A2=n1806 A1=n4747 B1=n1606
+ VDD=VDD B2=n4552 VSS=VSS
XU2208 FA1D0BWP7T $PINS CO=n1823 S=n1781 CI=n1803 B=n1804 VDD=VDD A=n1805
+ VSS=VSS
XU2207 FA1D0BWP7T $PINS CO=n1807 S=n1805 CI=n1800 B=n1801 VDD=VDD A=n1802
+ VSS=VSS
XU2206 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1814 A2=SA_core_connect<56>
+ A1=SA_core_connect<158>
XU2205 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1815 A2=n4601 A1=SA_core_connect<62>
XU2204 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4550 ZN=n1816 A2=n1798
XU2203 FA1D0BWP7T $PINS CO=n1821 S=n1804 CI=n1795 B=n1796 VDD=VDD A=n1797
+ VSS=VSS
XU2202 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3772 ZN=n1811 A2=n4548
XU2201 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4544 ZN=n1812 A2=n4600
XU2200 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3775 ZN=n1813 A2=n3819
XU2199 OA21D0BWP7T $PINS Z=n1831 A1=n1788 VDD=VDD A2=n4812 VSS=VSS B=n1838
XU2198 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n4846 A1=SA_core_connect<153>
+ ZN=n1838 A3=n4812
XU2197 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4667 ZN=n1788 A2=n4542
XU2196 FA1D0BWP7T $PINS CO=n1833 S=n1801 CI=n1783 B=n1784 VDD=VDD A=n1785
+ VSS=VSS
XU2195 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1780 ZN=n1825 A2=n1781 A1=n1782
XU2194 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1779 A1=n1781 ZN=n1780 A2=n1782
XU2193 MOAI22D1BWP7T $PINS A2=n1778 A1=n4470 ZN=SA_core_pe_2_2_N15 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<61> VDD=VDD
XU2192 XNR3D0BWP7T $PINS A1=n1779 A2=n1782 VDD=VDD VSS=VSS A3=n1781 ZN=n1778
XU2191 FA1D0BWP7T $PINS CO=n1803 S=n1766 CI=n1775 B=n1776 VDD=VDD A=n1777
+ VSS=VSS
XU2190 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3819 ZN=n1795 A2=n4600
XU2189 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3775 ZN=n1796 A2=n4548
XU2188 FA1D0BWP7T $PINS CO=n1800 S=n1768 CI=n1772 B=n1773 VDD=VDD A=n1774
+ VSS=VSS
XU2187 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1798 ZN=n1783 A2=n4624
XU2186 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3772 ZN=n1784 A2=n4550
XU2185 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4542 ZN=n1785 A2=n4602
XU2184 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1802 B=n1832 A2=n1769
+ A1=SA_core_shift_wire<69>
XU2183 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<153> VDD=VDD A2=n4543
+ A3=SA_core_shift_wire<69> Z=n1832
XU2182 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4667 ZN=n1769 A2=n4544
XU2181 FA1D0BWP7T $PINS CO=n1782 S=n1763 CI=n1766 B=n1767 VDD=VDD A=n1768
+ VSS=VSS
XU2180 FA1D0BWP7T $PINS CO=n1779 S=n1762 CI=n1763 B=n4753 VDD=VDD A=n1765
+ VSS=VSS
XU2179 AO22D0BWP7T $PINS Z=SA_core_pe_2_2_N14 A2=n1762 A1=n4747 B1=n1606
+ VDD=VDD B2=n4553 VSS=VSS
XU2178 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3775 ZN=n1775 A2=n4550
XU2177 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1776 B=n1797 A2=n1761
+ A1=SA_core_shift_wire<68>
XU2176 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<153> VDD=VDD
+ A2=SA_core_connect<59> A3=SA_core_shift_wire<68> Z=n1797
XU2175 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4667 ZN=n1761 A2=n3819
XU2174 FA1D0BWP7T $PINS CO=n1767 S=n1751 CI=n1758 B=n1759 VDD=VDD A=n1760
+ VSS=VSS
XU2173 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3772 ZN=n1772 A2=n4624
XU2172 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4600 ZN=n1773 A2=n4548
XU2171 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4544 ZN=n1774 A2=n4602
XU2168 INVD0BWP7T $PINS ZN=n1756 VSS=VSS VDD=VDD I=n1753
XU2167 FA1D0BWP7T $PINS CO=n1765 S=n1754 CI=n1750 B=n1751 VDD=VDD A=n1752
+ VSS=VSS
XU2166 MOAI22D0BWP7T $PINS A2=n4470 A1=n1749 ZN=SA_core_pe_2_2_N13 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<59> VDD=VDD
XU2165 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1754 A1=n1755 A3=n1753 Z=n1749
XU2164 FA1D0BWP7T $PINS CO=n1753 S=n1740 CI=n1746 B=n1747 VDD=VDD A=n1748
+ VSS=VSS
XU2163 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1750 B=n1777 A2=n1745
+ A1=SA_core_shift_wire<67>
XU2162 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<153> VDD=VDD A2=n4547
+ A3=SA_core_shift_wire<67> Z=n1777
XU2161 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4667 ZN=n1745 A2=n4548
XU2160 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3775 ZN=n1758 A2=n4624
XU2159 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3819 ZN=n1759 A2=n4602
XU2158 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4600 ZN=n1760 A2=n4550
XU2157 INVD0BWP7T $PINS ZN=n1752 VSS=VSS VDD=VDD I=n1744
XU2156 FA1D0BWP7T $PINS CO=n1755 S=n1739 CI=n1741 B=n1742 VDD=VDD A=n1743
+ VSS=VSS
XU2155 MOAI22D0BWP7T $PINS A2=n4470 A1=n1740 ZN=SA_core_pe_2_2_N12 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<58> VDD=VDD
XU2154 INVD0BWP7T $PINS ZN=n1746 VSS=VSS VDD=VDD I=n1739
XU2153 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4548 ZN=n1741 A2=n4602
XU2152 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4667 ZN=n1742 A2=n4550
XU2148 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4600 ZN=n1735 A2=n4624
XU2147 MOAI22D1BWP7T $PINS A2=n1734 A1=n4470 ZN=SA_core_pe_2_2_N11 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<57> VDD=VDD
XU2146 XNR3D0BWP7T $PINS A1=n1737 A2=n1738 VDD=VDD VSS=VSS A3=n1736 ZN=n1734
XU2145 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4550 ZN=n1736 A2=n4602
XU2144 INVD0BWP7T $PINS ZN=n1738 VSS=VSS VDD=VDD I=n1733
XU2142 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1743 A1=n4667 A3=n1732 A2=n4624
XU2141 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<153> ZN=n1731
+ A2=SA_core_connect<56>
XU2140 INVD0BWP7T $PINS ZN=n1732 VSS=VSS VDD=VDD I=SA_core_shift_wire<65>
XU2139 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1730 ZN=SA_core_pe_2_2_N10
+ A2=SA_core_shift_wire<56> A1=n1606
XU2138 OAI211D0BWP7T $PINS A2=n1729 ZN=n1730 A1=SA_core_shift_wire<64> B=n4747
+ VDD=VDD C=n1733 VSS=VSS
XU2137 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<56> A1=n4601
+ ZN=n1733 A3=SA_core_shift_wire<64>
XU2136 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4602 ZN=n1729 A2=n4624
XU2135 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_2_N25 A2=n4731
+ A1=SA_core_connect<63>
XU2134 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_2_N24 A2=n4731
+ A1=SA_core_connect<62>
XU2133 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N23 A2=n4542
XU2131 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N22 A2=n4544
XU2129 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N21 A2=n3819
XU2126 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N20 A2=n4548
XU2124 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N19 A2=n4550
XU2122 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_2_N18 A2=n4624
XU2342 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4596 ZN=n1948
+ A2=SA_core_connect<55>
XU2340 FA1D0BWP7T $PINS CO=n1946 S=n1926 CI=n1943 B=n1944 VDD=VDD A=n1945
+ VSS=VSS
XU2339 FA1D0BWP7T $PINS CO=n1950 S=n1928 CI=n1940 B=n1941 VDD=VDD A=n1942
+ VSS=VSS
XU2338 XOR4D0BWP7T $PINS A3=n1938 VDD=VDD A4=n1937 VSS=VSS A1=n4551 A2=n1930
+ Z=n1965
XU2337 FA1D0BWP7T $PINS CO=n1937 S=n1940 CI=n1934 B=n1935 VDD=VDD A=n1936
+ VSS=VSS
XU2336 FA1D0BWP7T $PINS CO=n1938 S=n1942 CI=n1931 B=n1932 VDD=VDD A=n1933
+ VSS=VSS
XU2334 FA1D0BWP7T $PINS CO=n1930 S=n1944 CI=n1927 B=n1928 VDD=VDD A=n1929
+ VSS=VSS
XU2333 AO22D0BWP7T $PINS Z=SA_core_pe_2_1_N16 A2=n1926 A1=n4747 B1=n1606
+ VDD=VDD B2=SA_core_shift_wire<54> VSS=VSS
XU2332 FA1D0BWP7T $PINS CO=n1943 S=n1901 CI=n1923 B=n1924 VDD=VDD A=n1925
+ VSS=VSS
XU2331 FA1D0BWP7T $PINS CO=n1927 S=n1925 CI=n1920 B=n1921 VDD=VDD A=n1922
+ VSS=VSS
XU2330 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1934 A2=n4825 A1=n4581
XU2329 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1935 A2=n4596 A1=SA_core_connect<54>
XU2328 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3825 ZN=n1936 A2=n4584
XU2327 FA1D0BWP7T $PINS CO=n1941 S=n1924 CI=n1915 B=n1916 VDD=VDD A=n1917
+ VSS=VSS
XU2326 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4587 ZN=n1931 A2=n3822
XU2325 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4546 ZN=n1932 A2=n4593
XU2324 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3756 ZN=n1933 A2=n4623
XU2323 OA21D0BWP7T $PINS Z=n1951 A1=n1908 VDD=VDD A2=n4552 VSS=VSS B=n1958
XU2322 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<53> A1=n4821
+ ZN=n1958 A3=n4552
XU2321 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4626 ZN=n1908 A2=n1906
XU2320 FA1D0BWP7T $PINS CO=n1953 S=n1921 CI=n1903 B=n1904 VDD=VDD A=n1905
+ VSS=VSS
XU2319 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1900 ZN=n1945 A2=n1901 A1=n1902
XU2318 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1899 A1=n1901 ZN=n1900 A2=n1902
XU2317 MOAI22D1BWP7T $PINS A2=n1898 A1=n4470 ZN=SA_core_pe_2_1_N15 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<53> VDD=VDD
XU2316 XNR3D0BWP7T $PINS A1=n1899 A2=n1902 VDD=VDD VSS=VSS A3=n1901 ZN=n1898
XU2315 FA1D0BWP7T $PINS CO=n1923 S=n1886 CI=n1895 B=n1896 VDD=VDD A=n1897
+ VSS=VSS
XU2314 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4623 ZN=n1915 A2=n4593
XU2313 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3756 ZN=n1916 A2=n3822
XU2312 FA1D0BWP7T $PINS CO=n1920 S=n1888 CI=n1892 B=n1893 VDD=VDD A=n1894
+ VSS=VSS
XU2311 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4584 ZN=n1903 A2=n4680
XU2310 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4587 ZN=n1904 A2=n3825
XU2309 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1906 ZN=n1905 A2=n4597
XU2307 AN3D1BWP7T $PINS VSS=VSS A1=n4821 VDD=VDD A2=n4545
+ A3=SA_core_shift_wire<61> Z=n1952
XU2306 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4626 ZN=n1889 A2=n4546
XU2305 FA1D0BWP7T $PINS CO=n1902 S=n1883 CI=n1886 B=n1887 VDD=VDD A=n1888
+ VSS=VSS
XU2304 FA1D0BWP7T $PINS CO=n1899 S=n1882 CI=n1883 B=n4750 VDD=VDD A=n1885
+ VSS=VSS
XU2303 AO22D0BWP7T $PINS Z=SA_core_pe_2_1_N14 A2=n1882 A1=n4747 B1=n1606
+ VDD=VDD B2=SA_core_shift_wire<52> VSS=VSS
XU2302 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3756 ZN=n1895 A2=n3825
XU2301 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1896 B=n1917 A2=n1881 A1=n4553
XU2300 AN3D1BWP7T $PINS VSS=VSS A1=n4821 VDD=VDD A2=n4622 A3=n4553 Z=n1917
XU2299 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4626 ZN=n1881 A2=n4623
XU2298 FA1D0BWP7T $PINS CO=n1887 S=n1871 CI=n1878 B=n1879 VDD=VDD A=n1880
+ VSS=VSS
XU2297 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4587 ZN=n1892 A2=n4680
XU2296 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4593 ZN=n1893 A2=n3822
XU2295 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4546 ZN=n1894 A2=n4597
XU2293 MAOI222D1BWP7T $PINS ZN=n1877 C=n1874 B=n1875 VDD=VDD A=n1876 VSS=VSS
XU2292 INVD0BWP7T $PINS ZN=n1876 VSS=VSS VDD=VDD I=n1873
XU2291 FA1D0BWP7T $PINS CO=n1885 S=n1874 CI=n1870 B=n1871 VDD=VDD A=n1872
+ VSS=VSS
XU2289 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1874 A1=n1875 A3=n1873 Z=n1869
XU2288 FA1D0BWP7T $PINS CO=n1873 S=n1860 CI=n1866 B=n1867 VDD=VDD A=n1868
+ VSS=VSS
XU2287 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1870 B=n1897 A2=n1865
+ A1=SA_core_shift_wire<59>
XU2286 AN3D1BWP7T $PINS VSS=VSS A1=n4821 VDD=VDD A2=SA_core_connect<50>
+ A3=SA_core_shift_wire<59> Z=n1897
XU2285 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4626 ZN=n1865 A2=n3822
XU2284 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3756 ZN=n1878 A2=n4680
XU2283 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4623 ZN=n1879 A2=n4597
XU2282 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4593 ZN=n1880 A2=n3825
XU2281 INVD0BWP7T $PINS ZN=n1872 VSS=VSS VDD=VDD I=n1864
XU2280 FA1D0BWP7T $PINS CO=n1875 S=n1859 CI=n1861 B=n1862 VDD=VDD A=n1863
+ VSS=VSS
XU2279 MOAI22D0BWP7T $PINS A2=n4470 A1=n1860 ZN=SA_core_pe_2_1_N12 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<50> VDD=VDD
XU2278 INVD0BWP7T $PINS ZN=n1866 VSS=VSS VDD=VDD I=n1859
XU2277 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3822 ZN=n1861 A2=n4597
XU2276 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4626 ZN=n1862 A2=n3825
XU2275 MAOI222D2BWP7T $PINS ZN=n1867 C=n1856 B=n4446 VDD=VDD A=n1858 VSS=VSS
XU2274 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1864 A1=SA_core_shift_wire<58>
+ ZN=n1868 A2=n1855
XU2273 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4825 A1=n4592 ZN=n1864
+ A3=SA_core_shift_wire<58>
XU2272 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4593 ZN=n1855 A2=n4680
XU2271 MOAI22D1BWP7T $PINS A2=n1854 A1=n4470 ZN=SA_core_pe_2_1_N11 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<49> VDD=VDD
XU2270 XNR3D0BWP7T $PINS A1=n1857 A2=n1858 VDD=VDD VSS=VSS A3=n1856 ZN=n1854
XU2269 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3825 ZN=n1856 A2=n4597
XU2268 INVD0BWP7T $PINS ZN=n1858 VSS=VSS VDD=VDD I=n1853
XU2265 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4821 ZN=n1851 A2=n4825
XU2264 INVD0BWP7T $PINS ZN=n1852 VSS=VSS VDD=VDD I=SA_core_shift_wire<57>
XU2263 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1849 ZN=SA_core_pe_2_1_N10
+ A2=SA_core_shift_wire<48> A1=n1606
XU2262 OAI211D0BWP7T $PINS A2=n1848 ZN=n1849 A1=SA_core_shift_wire<56> B=n4747
+ VDD=VDD C=n1853 VSS=VSS
XU2261 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4825 A1=n4596 ZN=n1853
+ A3=SA_core_shift_wire<56>
XU2260 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4597 ZN=n1848 A2=n4680
XU2259 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_1_N25 A2=n4731
+ A1=SA_core_connect<55>
XU2258 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_1_N24 A2=n4731
+ A1=SA_core_connect<54>
XU2257 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N23 A2=n1906
XU2256 INVD0BWP7T $PINS ZN=n1906 VSS=VSS VDD=VDD I=SA_core_connect<53>
XU2255 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N22 A2=n4546
XU2253 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N21 A2=n4623
XU2251 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N20 A2=n3822
XU2249 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N19 A2=n3825
XU2247 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_2_1_N18 A2=n4680
XU2245 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_1_N33 A2=n4729
+ A1=SA_core_connect<135>
XU2244 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_1_N32 A2=n4729 A1=n4581
XU2230 XNR4D0BWP7T $PINS A1=n1845 A2=n1844 ZN=n1846 A3=n1843 A4=n1842 VDD=VDD
+ VSS=VSS
XU2229 XNR4D0BWP7T $PINS A1=n1841 A2=n1840 ZN=n1842 A3=n1839 A4=n1838 VDD=VDD
+ VSS=VSS
XU2228 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<153> ZN=n1839
+ A2=SA_core_connect<62>
XU2454 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2034 ZN=n2072 A2=n3864
XU2453 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4657 ZN=n2073 A2=n3813
XU2452 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4537 ZN=n2074 A2=n3863
XU2451 FA1D0BWP7T $PINS CO=n2052 S=n2045 CI=n2029 B=n2030 VDD=VDD A=n2031
+ VSS=VSS
XU2450 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2054 A2=SA_row_2<0>
+ A1=SA_core_connect<110>
XU2449 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2028 ZN=n2055 A2=n4619
XU2448 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4632 ZN=n2056 A2=n2025
XU2446 MAOI222D1BWP7T $PINS ZN=n2024 C=n2021 B=n2022 VDD=VDD A=n2023 VSS=VSS
XU2445 AOI21D1BWP7T $PINS VSS=VSS A2=n2020 VDD=VDD A1=n2023 B=n2019
+ ZN=SA_core_pe_2_0_N15
XU2444 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4747 A1=n2023 ZN=n2019 A2=n2020
XU2442 FA1D0BWP7T $PINS CO=n2021 S=n2005 CI=n2016 B=n2017 VDD=VDD A=n2018
+ VSS=VSS
XU2441 FA1D0BWP7T $PINS CO=n2043 S=n2016 CI=n2013 B=n2014 VDD=VDD A=n2015
+ VSS=VSS
XU2440 FA1D0BWP7T $PINS CO=n2040 S=n2018 CI=n2010 B=n2011 VDD=VDD A=n2012
+ VSS=VSS
XU2439 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2041 B=n2050 A2=n2009
+ A1=SA_core_shift_wire<53>
XU2438 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<105> VDD=VDD A2=SA_row_2<4>
+ A3=SA_core_shift_wire<53> Z=n2050
XU2437 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4686 ZN=n2009 A2=n4657
XU2436 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2025 ZN=n2035 A2=n4636
XU2435 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2034 ZN=n2036 A2=n4632
XU2434 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3861 ZN=n2037 A2=n4619
XU2433 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3863 ZN=n2029 A2=n3813
XU2432 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4537 ZN=n2030 A2=n3864
XU2431 FA1D0BWP7T $PINS CO=n2023 S=n2004 CI=n2005 B=n4197 VDD=VDD A=n2007
+ VSS=VSS
XU2430 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_0_N14 A2=n4747 A1=n2004
XU2429 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4537 ZN=n2013 A2=n4632
XU2428 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2014 B=n2031 A2=n2003
+ A1=SA_core_shift_wire<52>
XU2427 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<105> VDD=VDD A2=SA_row_2<3>
+ A3=SA_core_shift_wire<52> Z=n2031
XU2426 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4686 ZN=n2003 A2=n3863
XU2425 FA1D0BWP7T $PINS CO=n2017 S=n1995 CI=n2000 B=n2001 VDD=VDD A=n2002
+ VSS=VSS
XU2424 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2034 ZN=n2010 A2=n4636
XU2423 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3813 ZN=n2011 A2=n3864
XU2422 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4657 ZN=n2012 A2=n4619
XU2420 FA1D0BWP7T $PINS CO=n2007 S=n1991 CI=n1994 B=n1995 VDD=VDD A=n1996
+ VSS=VSS
XU2419 AOI21D0BWP7T $PINS VSS=VSS A2=n1993 VDD=VDD A1=n1999 B=n1992
+ ZN=SA_core_pe_2_0_N13
XU2418 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4747 A1=n1999 ZN=n1992 A2=n1993
XU2417 AOI22D0BWP7T $PINS B1=n1990 A2=n1997 ZN=n1993 A1=n1991 VDD=VDD B2=n1998
+ VSS=VSS
XU2416 INVD0BWP7T $PINS ZN=n1998 VSS=VSS VDD=VDD I=n1991
XU2415 INVD0BWP7T $PINS ZN=n1997 VSS=VSS VDD=VDD I=n1990
XU2414 FA1D0BWP7T $PINS CO=n1990 S=n1980 CI=n1987 B=n1988 VDD=VDD A=n1989
+ VSS=VSS
XU2413 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1994 B=n2015 A2=n1986
+ A1=SA_core_shift_wire<51>
XU2412 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<105> VDD=VDD A2=SA_row_2<2>
+ A3=SA_core_shift_wire<51> Z=n2015
XU2411 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4686 ZN=n1986 A2=n3864
XU2410 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4537 ZN=n2000 A2=n4636
XU2409 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3863 ZN=n2001 A2=n4619
XU2408 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3813 ZN=n2002 A2=n4632
XU2407 INVD0BWP7T $PINS ZN=n1996 VSS=VSS VDD=VDD I=n1985
XU2406 FA1D0BWP7T $PINS CO=n1999 S=n1981 CI=n1982 B=n1983 VDD=VDD A=n1984
+ VSS=VSS
XU2405 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1981 ZN=SA_core_pe_2_0_N12 A2=n4470
XU2404 INVD0BWP7T $PINS ZN=n1982 VSS=VSS VDD=VDD I=n1980
XU2403 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3864 ZN=n1987 A2=n4619
XU2402 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4686 ZN=n1988 A2=n4632
XU2400 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1985 A1=SA_core_shift_wire<50>
+ ZN=n1984 A2=n1976
XU2399 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_row_2<0> A1=SA_core_connect<106>
+ ZN=n1985 A3=SA_core_shift_wire<50>
XU2398 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3813 ZN=n1976 A2=n4636
XU2397 AOI21D0BWP7T $PINS VSS=VSS A2=n1975 VDD=VDD A1=n1978 B=n1974
+ ZN=SA_core_pe_2_0_N11
XU2396 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4747 A1=n1978 ZN=n1974 A2=n1975
XU2394 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4632 ZN=n1977 A2=n4619
XU2391 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<105> ZN=n1972
+ A2=SA_row_2<0>
XU2389 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1979 A2=n1970 A1=n1971
+ ZN=SA_core_pe_2_0_N10 C=n4470
XU2387 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4618 ZN=n1970 A2=SA_row_2<0>
XU2386 INVD0BWP7T $PINS ZN=n1971 VSS=VSS VDD=VDD I=SA_core_shift_wire<48>
XU2385 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_0_N25 A2=n4729
+ A1=SA_row_2<7>
XU2384 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N24 A2=n2028
XU2383 INVD0BWP7T $PINS ZN=n2028 VSS=VSS VDD=VDD I=SA_row_2<6>
XU2382 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N23 A2=n3861
XU2380 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N22 A2=n4657
XU2376 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N20 A2=n3864
XU2373 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N19 A2=n4632
XU2369 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_0_N33 A2=n4729
+ A1=SA_core_connect<111>
XU2368 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_0_N32 A2=n4729
+ A1=SA_core_connect<110>
XU2367 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N31 A2=n2025
XU2366 INVD1BWP7T $PINS ZN=n2025 VSS=VSS VDD=VDD I=SA_core_connect<109>
XU2365 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N30 A2=n2034
XU2363 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N29 A2=n4537
XU2361 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N28 A2=n3813
XU2355 MOAI22D0BWP7T $PINS A2=n1967 A1=n4470 ZN=SA_core_pe_2_1_N17 B1=n1606
+ VSS=VSS B2=SA_core_shift_wire<55> VDD=VDD
XU2354 XNR4D0BWP7T $PINS A1=n1965 A2=n1964 ZN=n1967 A3=n1963 A4=n1962 VDD=VDD
+ VSS=VSS
XU2353 XNR4D0BWP7T $PINS A1=n1961 A2=n1960 ZN=n1962 A3=n1959 A4=n1958 VDD=VDD
+ VSS=VSS
XU2352 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4821 ZN=n1959
+ A2=SA_core_connect<54>
XU2351 XOR4D0BWP7T $PINS A3=n1955 VDD=VDD A4=n1954 VSS=VSS A1=n1957 A2=n1956
+ Z=n1960
XU2350 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4581 ZN=n1954
+ A2=SA_core_connect<49>
XU2349 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<53> ZN=n1955
+ A2=n4592
XU2348 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<132> ZN=n1956
+ A2=n4622
XU2347 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<131> ZN=n1957
+ A2=n4545
XU2346 FA1D0BWP7T $PINS CO=n1961 S=n1929 CI=n1951 B=n1952 VDD=VDD A=n1953
+ VSS=VSS
XU2345 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<133> ZN=n1963
+ A2=SA_core_connect<50>
XU2344 XOR4D0BWP7T $PINS A3=n1948 VDD=VDD A4=n1947 VSS=VSS A1=n1950 A2=n1946
+ Z=n1964
XU2343 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4825 ZN=n1947
+ A2=SA_core_connect<135>
XU2571 FA1D0BWP7T $PINS CO=n2174 S=n2138 CI=n2148 B=n2149 VDD=VDD A=n2150
+ VSS=VSS
XU2570 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4615 ZN=n2166 A2=n4608
XU2569 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3790 ZN=n2167 A2=n4617
XU2568 FA1D0BWP7T $PINS CO=n2171 S=n2140 CI=n2145 B=n2146 VDD=VDD A=n2147
+ VSS=VSS
XU2567 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2169 ZN=n2156 A2=n4690
XU2566 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3787 ZN=n2157 A2=n3804
XU2565 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2158 A2=n4609 A1=n4824
XU2562 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4645 ZN=n2142
+ A2=SA_core_connect<44>
XU2561 INVD0BWP7T $PINS ZN=n2143 VSS=VSS VDD=VDD I=SA_core_output_row_1<5>
XU2560 FA1D0BWP7T $PINS CO=n2155 S=n2135 CI=n2138 B=n2139 VDD=VDD A=n2140
+ VSS=VSS
XU2559 FA1D0BWP7T $PINS CO=n2152 S=n2134 CI=n2135 B=n4744 VDD=VDD A=n2137
+ VSS=VSS
XU2558 AO22D0BWP7T $PINS Z=SA_core_pe_1_3_N14 A2=n2134 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<44> VSS=VSS
XU2557 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3790 ZN=n2148 A2=n3804
XU2556 AOI21D1BWP7T $PINS VSS=VSS A2=n2132 VDD=VDD A1=n2133 B=n2168 ZN=n2149
XU2554 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4645 ZN=n2132 A2=n4614
XU2553 INVD0BWP7T $PINS ZN=n2133 VSS=VSS VDD=VDD I=n4828
XU2552 FA1D0BWP7T $PINS CO=n2139 S=n2121 CI=n2129 B=n2130 VDD=VDD A=n2131
+ VSS=VSS
XU2551 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3787 ZN=n2145 A2=n4690
XU2550 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4608 ZN=n2146 A2=n4617
XU2549 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2163 ZN=n2147 A2=n4610
XU2548 INVD0BWP7T $PINS ZN=n2163 VSS=VSS VDD=VDD I=SA_core_connect<44>
XU2545 INVD0BWP7T $PINS ZN=n2126 VSS=VSS VDD=VDD I=n2123
XU2544 FA1D0BWP7T $PINS CO=n2137 S=n2124 CI=n2120 B=n2121 VDD=VDD A=n2122
+ VSS=VSS
XU2543 IOA22D2BWP7T $PINS A2=SA_core_shift_wire<43> A1=n2097
+ ZN=SA_core_pe_1_3_N13 B1=n2119 VSS=VSS B2=n4745 VDD=VDD
XU2542 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2124 A1=n2125 A3=n2123 Z=n2119
XU2541 FA1D0BWP7T $PINS CO=n2123 S=n2109 CI=n2116 B=n4235 VDD=VDD A=n4807
+ VSS=VSS
XU2539 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2150 A1=n4646 A3=n2115 A2=n4617
XU2538 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4645 ZN=n2114 A2=n4616
XU2537 INVD0BWP7T $PINS ZN=n2115 VSS=VSS VDD=VDD I=SA_core_output_row_1<3>
XU2536 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3790 ZN=n2129 A2=n4690
XU2535 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4615 ZN=n2130 A2=n4610
XU2533 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4608 ZN=n2131 A2=n3804
XU2532 INVD0BWP7T $PINS ZN=n2122 VSS=VSS VDD=VDD I=n2113
XU2531 FA1D0BWP7T $PINS CO=n2125 S=n2108 CI=n2110 B=n2111 VDD=VDD A=n2112
+ VSS=VSS
XU2529 INVD0BWP7T $PINS ZN=n2116 VSS=VSS VDD=VDD I=n2108
XU2528 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4617 ZN=n2110 A2=n4610
XU2526 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4646 ZN=n2111 A2=n3804
XU2524 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2113 A1=SA_core_output_row_1<2>
+ ZN=n2118 A2=n2104
XU2523 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<40> A1=n4607
+ ZN=n2113 A3=SA_core_output_row_1<2>
XU2521 MOAI22D0BWP7T $PINS A2=n2103 A1=n4745 ZN=SA_core_pe_1_3_N11 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<41> VDD=VDD
XU2519 XNR3D0BWP7T $PINS A1=n2106 A2=n2107 VDD=VDD VSS=VSS A3=n2105 ZN=n2103
XU2518 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3804 ZN=n2105 A2=n4610
XU2516 INVD0BWP7T $PINS ZN=n2107 VSS=VSS VDD=VDD I=n2101
XU2514 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2112 A1=n4646 A3=n2099 A2=n4690
XU2512 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4645 ZN=n2100
+ A2=SA_core_connect<40>
XU2511 MOAI22D0BWP7T $PINS A2=n2098 A1=n4745 ZN=SA_core_pe_1_3_N10 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<40> VDD=VDD
XU2507 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2101 A1=n2095 ZN=n2098 A2=n4844
XU2505 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4610 ZN=n2095 A2=n4690
XU2499 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_3_N33 A2=n4729 A1=n4603
XU2498 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_3_N32 A2=n4729 A1=n4620
XU2497 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N31 A2=n2169
XU2495 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N30 A2=n3787
XU2493 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N29 A2=n3790
XU2491 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N28 A2=n4608
XU2489 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N27 A2=n4646
XU2487 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_3_N26 A2=n4610
XU2485 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4470 A2=n2093 A1=n2094
+ ZN=SA_core_pe_2_0_N17 C=n2091
XU2484 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2094 ZN=n2091 A2=n2093
XU2483 XNR4D0BWP7T $PINS A1=n2063 A2=n2089 ZN=n2093 A3=n2088 A4=n2087 VDD=VDD
+ VSS=VSS
XU2482 XNR4D0BWP7T $PINS A1=n2086 A2=n2085 ZN=n2087 A3=n2084 A4=n2083 VDD=VDD
+ VSS=VSS
XU2481 XNR4D0BWP7T $PINS A1=n2082 A2=n2078 ZN=n2083 A3=n2080 A4=n2079 VDD=VDD
+ VSS=VSS
XU2480 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_2<0> ZN=n2079
+ A2=SA_core_connect<111>
XU2479 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_2<7> ZN=n2080 A2=n4618
XU2477 FA1D0BWP7T $PINS CO=n2078 S=n2061 CI=n2075 B=n2076 VDD=VDD A=n2077
+ VSS=VSS
XU2476 FA1D0BWP7T $PINS CO=n2082 S=n2051 CI=n2072 B=n2073 VDD=VDD A=n2074
+ VSS=VSS
XU2475 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_2<2> ZN=n2084
+ A2=SA_core_connect<109>
XU2473 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2070 A1=n4537 ZN=n2068 A2=n4657
XU2472 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<108> ZN=n2070
+ A2=SA_row_2<3>
XU2470 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2066 A1=n3813 ZN=n2064 A2=n3861
XU2469 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<110> ZN=n2066
+ A2=SA_row_2<1>
XU2468 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_2<6> ZN=n2089
+ A2=SA_core_connect<105>
XU2466 FA1D0BWP7T $PINS CO=n2063 S=n2047 CI=n2060 B=n2061 VDD=VDD A=n3993
+ VSS=VSS
XU2465 XOR4D0BWP7T $PINS A3=n2058 VDD=VDD A4=n2057 VSS=VSS
+ A1=SA_core_shift_wire<55> A2=n2059 Z=n2094
XU2464 FA1D0BWP7T $PINS CO=n2057 S=n2053 CI=n2054 B=n2055 VDD=VDD A=n2056
+ VSS=VSS
XU2463 FA1D0BWP7T $PINS CO=n2058 S=n2077 CI=n2051 B=n2052 VDD=VDD A=n2053
+ VSS=VSS
XU2462 FA1D0BWP7T $PINS CO=n2059 S=n2076 CI=n2048 B=n2049 VDD=VDD A=n2050
+ VSS=VSS
XU2461 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_2_0_N16 A2=n4747 A1=n2047
XU2460 FA1D0BWP7T $PINS CO=n2060 S=n2022 CI=n2043 B=n2044 VDD=VDD A=n2045
+ VSS=VSS
XU2459 FA1D0BWP7T $PINS CO=n2075 S=n2044 CI=n2040 B=n2041 VDD=VDD A=n2042
+ VSS=VSS
XU2458 OA21D0BWP7T $PINS Z=n2048 A1=n2039 VDD=VDD A2=SA_core_shift_wire<54>
+ VSS=VSS B=n2088
XU2457 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_row_2<5> A1=SA_core_connect<105>
+ ZN=n2088 A3=SA_core_shift_wire<54>
XU2456 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4686 ZN=n2039 A2=n3861
XU2455 FA1D0BWP7T $PINS CO=n2049 S=n2042 CI=n2035 B=n2036 VDD=VDD A=n2037
+ VSS=VSS
XU2681 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<145> VDD=VDD
+ A2=SA_core_connect<35> A3=SA_core_shift_wire<44> Z=n2288
XU2680 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4627 ZN=n2252 A2=n3800
XU2679 FA1D0BWP7T $PINS CO=n2258 S=n2242 CI=n2249 B=n2250 VDD=VDD A=n2251
+ VSS=VSS
XU2678 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3773 ZN=n2263 A2=n4681
XU2677 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3779 ZN=n2264 A2=n3802
XU2676 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2283 ZN=n2265 A2=n4631
XU2673 INVD0BWP7T $PINS ZN=n2247 VSS=VSS VDD=VDD I=n2244
XU2672 FA1D0BWP7T $PINS CO=n2256 S=n2245 CI=n2241 B=n2242 VDD=VDD A=n2243
+ VSS=VSS
XU2671 MOAI22D0BWP7T $PINS A2=n4745 A1=n2240 ZN=SA_core_pe_1_2_N13 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<35> VDD=VDD
XU2670 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2245 A1=n2246 A3=n2244 Z=n2240
XU2669 FA1D0BWP7T $PINS CO=n2244 S=n2231 CI=n2237 B=n2238 VDD=VDD A=n2239
+ VSS=VSS
XU2667 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<145> VDD=VDD
+ A2=SA_core_connect<34> A3=SA_core_shift_wire<43> Z=n2268
XU2666 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4627 ZN=n2236 A2=n3802
XU2665 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3776 ZN=n2249 A2=n4681
XU2664 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3800 ZN=n2250 A2=n4631
XU2663 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3779 ZN=n2251 A2=n3805
XU2662 INVD0BWP7T $PINS ZN=n2243 VSS=VSS VDD=VDD I=n2235
XU2661 FA1D0BWP7T $PINS CO=n2246 S=n2230 CI=n2232 B=n2233 VDD=VDD A=n2234
+ VSS=VSS
XU2660 IOA22D2BWP7T $PINS A2=SA_core_shift_wire<34> A1=n2097
+ ZN=SA_core_pe_1_2_N12 B1=n2231 VSS=VSS B2=n4745 VDD=VDD
XU2659 INVD0BWP7T $PINS ZN=n2237 VSS=VSS VDD=VDD I=n2230
XU2658 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3802 ZN=n2232 A2=n4631
XU2657 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4627 ZN=n2233 A2=n3805
XU2656 MAOI222D1BWP7T $PINS ZN=n2238 C=n2227 B=n4448 VDD=VDD A=n2229 VSS=VSS
XU2654 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<32>
+ A1=SA_core_connect<146> ZN=n2235 A3=SA_core_shift_wire<42>
XU2653 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3779 ZN=n2226 A2=n4681
XU2652 MOAI22D0BWP7T $PINS A2=n2225 A1=n4745 ZN=SA_core_pe_1_2_N11 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<33> VDD=VDD
XU2651 XNR3D0BWP7T $PINS A1=n2228 A2=n2229 VDD=VDD VSS=VSS A3=n2227 ZN=n2225
XU2650 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3805 ZN=n2227 A2=n4631
XU2649 INVD0BWP7T $PINS ZN=n2229 VSS=VSS VDD=VDD I=n2224
XU2647 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2234 A1=n4627 A3=n2223 A2=n4681
XU2646 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<145> ZN=n2222
+ A2=SA_core_connect<32>
XU2644 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2221 ZN=SA_core_pe_1_2_N10
+ A2=SA_core_shift_wire<32> A1=n2097
XU2643 OAI211D0BWP7T $PINS A2=n2220 ZN=n2221 A1=SA_core_shift_wire<40> B=n2538
+ VDD=VDD C=n2224 VSS=VSS
XU2642 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<32>
+ A1=SA_core_connect<144> ZN=n2224 A3=SA_core_shift_wire<40>
XU2641 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4631 ZN=n2220 A2=n4681
XU2640 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_2_N25 A2=n4729
+ A1=SA_core_connect<39>
XU2638 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N23 A2=n4613
XU2635 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N22 A2=n2283
XU2633 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N21 A2=n3800
XU2631 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N20 A2=n3802
XU2629 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N19 A2=n3805
XU2627 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N18 A2=n4681
XU2625 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_2_N33 A2=n4731
+ A1=SA_core_connect<151>
XU2624 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_2_N32 A2=n4731
+ A1=SA_core_connect<150>
XU2623 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N31 A2=n3770
XU2621 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N30 A2=n3773
XU2619 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N29 A2=n3776
XU2617 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N28 A2=n3779
XU2615 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N27 A2=n4627
XU2613 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_2_N26 A2=n4631
XU2610 XNR4D0BWP7T $PINS A1=n2216 A2=n2215 ZN=n2217 A3=n2214 A4=n2213 VDD=VDD
+ VSS=VSS
XU2609 XNR4D0BWP7T $PINS A1=n2212 A2=n2211 ZN=n2213 A3=n2210 A4=n2209 VDD=VDD
+ VSS=VSS
XU2608 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4645 ZN=n2210 A2=n4849
XU2607 XOR4D0BWP7T $PINS A3=n2206 VDD=VDD A4=n2205 VSS=VSS A1=n2208 A2=n2207
+ Z=n2211
XU2606 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4620 ZN=n2205 A2=n4833
XU2605 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4824 ZN=n2206 A2=n4607
XU2604 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4811 ZN=n2207 A2=n4614
XU2603 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4848 ZN=n2208
+ A2=SA_core_connect<44>
XU2602 FA1D0BWP7T $PINS CO=n2212 S=n2180 CI=n2202 B=n2203 VDD=VDD A=n2204
+ VSS=VSS
XU2601 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<173> ZN=n2214
+ A2=n4616
XU2600 XOR4D0BWP7T $PINS A3=n2199 VDD=VDD A4=n2198 VSS=VSS A1=n2201 A2=n2197
+ Z=n2215
XU2599 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<40> ZN=n2198
+ A2=n4603
XU2598 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4609 ZN=n2199
+ A2=SA_core_connect<47>
XU2596 FA1D0BWP7T $PINS CO=n2197 S=n2177 CI=n2194 B=n2195 VDD=VDD A=n2196
+ VSS=VSS
XU2595 FA1D0BWP7T $PINS CO=n2201 S=n2179 CI=n2191 B=n2192 VDD=VDD A=n2193
+ VSS=VSS
XU2594 XOR4D0BWP7T $PINS A3=n2189 VDD=VDD A4=n2188 VSS=VSS A1=n2181
+ A2=SA_core_output_row_1<7> Z=n2216
XU2593 FA1D0BWP7T $PINS CO=n2188 S=n2191 CI=n2185 B=n2186 VDD=VDD A=n2187
+ VSS=VSS
XU2592 FA1D0BWP7T $PINS CO=n2189 S=n2193 CI=n2182 B=n2183 VDD=VDD A=n2184
+ VSS=VSS
XU2590 FA1D0BWP7T $PINS CO=n2181 S=n2195 CI=n2178 B=n2179 VDD=VDD A=n2180
+ VSS=VSS
XU2589 AO22D0BWP7T $PINS Z=SA_core_pe_1_3_N16 A2=n2177 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<46> VSS=VSS
XU2588 FA1D0BWP7T $PINS CO=n2194 S=n2154 CI=n2174 B=n2175 VDD=VDD A=n2176
+ VSS=VSS
XU2587 FA1D0BWP7T $PINS CO=n2178 S=n2176 CI=n2171 B=n2172 VDD=VDD A=n2173
+ VSS=VSS
XU2586 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2185 A2=SA_core_connect<40> A1=n4620
XU2585 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2186 A2=n4609 A1=n4849
XU2584 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3804 ZN=n2187 A2=n2169
XU2583 FA1D0BWP7T $PINS CO=n2192 S=n2175 CI=n2166 B=n2167 VDD=VDD A=n2168
+ VSS=VSS
XU2582 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3787 ZN=n2182 A2=n4617
XU2581 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2163 ZN=n2183 A2=n4608
XU2580 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3790 ZN=n2184 A2=n4615
XU2579 OA21D0BWP7T $PINS Z=n2202 A1=n2159 VDD=VDD A2=n4839 VSS=VSS B=n2209
XU2578 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4824 A1=n4645 ZN=n2209 A3=n4839
XU2577 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2159 A2=n4645 A1=n4824
XU2576 FA1D0BWP7T $PINS CO=n2204 S=n2172 CI=n2156 B=n2157 VDD=VDD A=n2158
+ VSS=VSS
XU2575 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2153 ZN=n2196 A2=n2154 A1=n2155
XU2574 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2152 A1=n2154 ZN=n2153 A2=n2155
XU2573 MOAI22D0BWP7T $PINS A2=n2151 A1=n4745 ZN=SA_core_pe_1_3_N15 B1=n2097
+ VSS=VSS B2=n4538 VDD=VDD
XU2572 XNR3D0BWP7T $PINS A1=n2152 A2=n2155 VDD=VDD VSS=VSS A3=n2154 ZN=n2151
XU2788 INVD0BWP7T $PINS ZN=n2364 VSS=VSS VDD=VDD I=n2356
XU2787 FA1D0BWP7T $PINS CO=n2367 S=n2351 CI=n2353 B=n2354 VDD=VDD A=n2355
+ VSS=VSS
XU2786 MOAI22D0BWP7T $PINS A2=n4745 A1=n2352 ZN=SA_core_pe_1_1_N12 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<26> VDD=VDD
XU2785 INVD0BWP7T $PINS ZN=n2358 VSS=VSS VDD=VDD I=n2351
XU2784 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4813 ZN=n2353 A2=n4630
XU2783 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4666 ZN=n2354 A2=n3806
XU2782 MAOI222D1BWP7T $PINS ZN=n2359 C=n2348 B=n4449 VDD=VDD A=n2350 VSS=VSS
XU2781 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2356 A1=SA_core_shift_wire<34>
+ ZN=n2360 A2=n2347
XU2780 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<24> A1=n4838
+ ZN=n2356 A3=SA_core_shift_wire<34>
XU2779 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3759 ZN=n2347 A2=n4637
XU2778 MOAI22D0BWP7T $PINS A2=n2346 A1=n4745 ZN=SA_core_pe_1_1_N11 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<25> VDD=VDD
XU2777 XNR3D0BWP7T $PINS A1=n2349 A2=n2350 VDD=VDD VSS=VSS A3=n2348 ZN=n2346
XU2776 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3806 ZN=n2348 A2=n4630
XU2775 INVD0BWP7T $PINS ZN=n2350 VSS=VSS VDD=VDD I=n2345
XU2773 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2355 A1=n4666 A3=n2344 A2=n4637
XU2772 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<121> ZN=n2343
+ A2=SA_core_connect<24>
XU2771 INVD0BWP7T $PINS ZN=n2344 VSS=VSS VDD=VDD I=SA_core_shift_wire<33>
XU2770 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2341 ZN=SA_core_pe_1_1_N10
+ A2=SA_core_shift_wire<24> A1=n2097
XU2769 OAI211D0BWP7T $PINS A2=n2340 ZN=n2341 A1=SA_core_shift_wire<32> B=n2538
+ VDD=VDD C=n2345 VSS=VSS
XU2768 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<24>
+ A1=SA_core_connect<120> ZN=n2345 A3=SA_core_shift_wire<32>
XU2767 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4630 ZN=n2340 A2=n4637
XU2766 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_1_N25 A2=n4731
+ A1=SA_core_connect<31>
XU2765 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_1_N24 A2=n4731
+ A1=SA_core_connect<30>
XU2764 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N23 A2=n2398
XU2763 INVD0BWP7T $PINS ZN=n2398 VSS=VSS VDD=VDD I=SA_core_connect<29>
XU2760 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N22 A2=n2404
XU2758 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N21 A2=n3801
XU2756 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N20 A2=n4813
XU2754 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N19 A2=n3806
XU2752 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_1_1_N18 A2=n4637
XU2750 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_1_N33 A2=n4731 A1=n4580
XU2749 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_1_N32 A2=n4731 A1=n4582
XU2748 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N31 A2=n4585
XU2746 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N30 A2=n3755
XU2744 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N29 A2=n3757
XU2742 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N28 A2=n3759
XU2740 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N27 A2=n4666
XU2738 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_1_N26 A2=n4630
XU2736 MOAI22D1BWP7T $PINS A2=n2337 A1=n4745 ZN=SA_core_pe_1_2_N17 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<39> VDD=VDD
XU2735 XNR4D0BWP7T $PINS A1=n2336 A2=n2335 ZN=n2337 A3=n2334 A4=n2333 VDD=VDD
+ VSS=VSS
XU2734 XNR4D0BWP7T $PINS A1=n2332 A2=n2331 ZN=n2333 A3=n2330 A4=n2329 VDD=VDD
+ VSS=VSS
XU2733 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<145> ZN=n2330
+ A2=n4611
XU2732 XOR4D0BWP7T $PINS A3=n2326 VDD=VDD A4=n2325 VSS=VSS A1=n2328 A2=n2327
+ Z=n2331
XU2731 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<150> ZN=n2325
+ A2=SA_core_connect<33>
XU2730 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4837 ZN=n2326
+ A2=SA_core_connect<146>
XU2729 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<148> ZN=n2327
+ A2=SA_core_connect<35>
XU2728 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<147> ZN=n2328
+ A2=n4818
XU2727 FA1D0BWP7T $PINS CO=n2332 S=n2300 CI=n2322 B=n2323 VDD=VDD A=n2324
+ VSS=VSS
XU2726 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<149> ZN=n2334
+ A2=SA_core_connect<34>
XU2725 XOR4D0BWP7T $PINS A3=n2319 VDD=VDD A4=n2318 VSS=VSS A1=n2321 A2=n2317
+ Z=n2335
XU2724 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<32> ZN=n2318
+ A2=SA_core_connect<151>
XU2723 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<144> ZN=n2319
+ A2=SA_core_connect<39>
XU2721 FA1D0BWP7T $PINS CO=n2317 S=n2297 CI=n2314 B=n2315 VDD=VDD A=n2316
+ VSS=VSS
XU2720 FA1D0BWP7T $PINS CO=n2321 S=n2299 CI=n2311 B=n2312 VDD=VDD A=n2313
+ VSS=VSS
XU2719 XOR4D0BWP7T $PINS A3=n2309 VDD=VDD A4=n2308 VSS=VSS
+ A1=SA_core_shift_wire<47> A2=n2301 Z=n2336
XU2718 FA1D0BWP7T $PINS CO=n2308 S=n2311 CI=n2305 B=n2306 VDD=VDD A=n2307
+ VSS=VSS
XU2717 FA1D0BWP7T $PINS CO=n2309 S=n2313 CI=n2302 B=n2303 VDD=VDD A=n2304
+ VSS=VSS
XU2715 FA1D0BWP7T $PINS CO=n2301 S=n2315 CI=n2298 B=n2299 VDD=VDD A=n2300
+ VSS=VSS
XU2714 AO22D0BWP7T $PINS Z=SA_core_pe_1_2_N16 A2=n2297 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<38> VSS=VSS
XU2713 FA1D0BWP7T $PINS CO=n2314 S=n2272 CI=n2294 B=n2295 VDD=VDD A=n2296
+ VSS=VSS
XU2712 FA1D0BWP7T $PINS CO=n2298 S=n2296 CI=n2291 B=n2292 VDD=VDD A=n2293
+ VSS=VSS
XU2711 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2305 A2=SA_core_connect<32>
+ A1=SA_core_connect<150>
XU2710 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2306 A2=SA_core_connect<144>
+ A1=n4611
XU2709 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3805 ZN=n2307 A2=n3770
XU2708 FA1D0BWP7T $PINS CO=n2312 S=n2295 CI=n2286 B=n2287 VDD=VDD A=n2288
+ VSS=VSS
XU2707 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3773 ZN=n2302 A2=n3802
XU2706 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2283 ZN=n2303 A2=n3779
XU2705 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3776 ZN=n2304 A2=n3800
XU2704 OA21D0BWP7T $PINS Z=n2322 A1=n2279 VDD=VDD A2=SA_core_shift_wire<46>
+ VSS=VSS B=n2329
XU2703 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4837 A1=SA_core_connect<145>
+ ZN=n2329 A3=SA_core_shift_wire<46>
XU2702 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4627 ZN=n2279 A2=n4613
XU2701 FA1D0BWP7T $PINS CO=n2324 S=n2292 CI=n2274 B=n2275 VDD=VDD A=n2276
+ VSS=VSS
XU2700 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2271 ZN=n2316 A2=n2272 A1=n2273
XU2699 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2270 A1=n2272 ZN=n2271 A2=n2273
XU2698 MOAI22D0BWP7T $PINS A2=n2269 A1=n4745 ZN=SA_core_pe_1_2_N15 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<37> VDD=VDD
XU2697 XNR3D0BWP7T $PINS A1=n2270 A2=n2273 VDD=VDD VSS=VSS A3=n2272 ZN=n2269
XU2696 FA1D0BWP7T $PINS CO=n2294 S=n2257 CI=n2266 B=n2267 VDD=VDD A=n2268
+ VSS=VSS
XU2695 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3800 ZN=n2286 A2=n3779
XU2694 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3776 ZN=n2287 A2=n3802
XU2693 FA1D0BWP7T $PINS CO=n2291 S=n2259 CI=n2263 B=n2264 VDD=VDD A=n2265
+ VSS=VSS
XU2692 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3770 ZN=n2274 A2=n4681
XU2691 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3773 ZN=n2275 A2=n3805
XU2690 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4613 ZN=n2276 A2=n4631
XU2689 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2293 B=n2323 A2=n2260 A1=n4538
XU2688 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<145> VDD=VDD A2=n4818
+ A3=n4538 Z=n2323
XU2687 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4627 ZN=n2260 A2=n2283
XU2686 FA1D0BWP7T $PINS CO=n2273 S=n2254 CI=n2257 B=n2258 VDD=VDD A=n2259
+ VSS=VSS
XU2685 FA1D0BWP7T $PINS CO=n2270 S=n2253 CI=n2254 B=n4176 VDD=VDD A=n2256
+ VSS=VSS
XU2684 AO22D0BWP7T $PINS Z=SA_core_pe_1_2_N14 A2=n2253 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<36> VSS=VSS
XU2683 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3776 ZN=n2266 A2=n3805
XU2898 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<97> ZN=n2464
+ A2=SA_row_1<0>
XU2896 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n2471 A2=n2462 A1=n2463
+ ZN=SA_core_pe_1_0_N10 C=n4745
XU2894 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4531 ZN=n2462 A2=SA_row_1<0>
XU2893 INVD0BWP7T $PINS ZN=n2463 VSS=VSS VDD=VDD I=SA_core_shift_wire<24>
XU2891 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_1_0_N24 A2=n2520
XU2890 INVD0BWP7T $PINS ZN=n2520 VSS=VSS VDD=VDD I=SA_row_1<6>
XU2889 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_1_0_N23 A2=n3855
XU2884 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N21 A2=n3857
XU2882 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N20 A2=n3858
XU2880 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N19 A2=n4536
XU2878 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N18 A2=n4643
XU2876 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_0_N33 A2=n4731
+ A1=SA_core_connect<103>
XU2875 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_0_N32 A2=n4731
+ A1=SA_core_connect<102>
XU2874 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N31 A2=n2517
XU2873 INVD0BWP7T $PINS ZN=n2517 VSS=VSS VDD=VDD I=SA_core_connect<101>
XU2872 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N30 A2=n2526
XU2870 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N29 A2=n3851
XU2868 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N28 A2=n4530
XU2866 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N27 A2=n4687
XU2864 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4730 ZN=SA_core_pe_1_0_N26 A2=n4532
XU2862 MOAI22D1BWP7T $PINS A2=n2459 A1=n4745 ZN=SA_core_pe_1_1_N17 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<31> VDD=VDD
XU2861 XNR4D0BWP7T $PINS A1=n2457 A2=n2456 ZN=n2459 A3=n2455 A4=n2454 VDD=VDD
+ VSS=VSS
XU2860 XNR4D0BWP7T $PINS A1=n2453 A2=n2452 ZN=n2454 A3=n2451 A4=n2450 VDD=VDD
+ VSS=VSS
XU2859 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<121> ZN=n2451
+ A2=SA_core_connect<30>
XU2858 XOR4D0BWP7T $PINS A3=n2447 VDD=VDD A4=n2446 VSS=VSS A1=n2449 A2=n2448
+ Z=n2452
XU2857 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4582 ZN=n2446
+ A2=SA_core_connect<25>
XU2856 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<29> ZN=n2447
+ A2=n4838
XU2855 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<124> ZN=n2448
+ A2=SA_core_connect<27>
XU2854 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<123> ZN=n2449
+ A2=n4841
XU2853 FA1D0BWP7T $PINS CO=n2453 S=n2421 CI=n2443 B=n2444 VDD=VDD A=n2445
+ VSS=VSS
XU2852 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<125> ZN=n2455
+ A2=SA_core_connect<26>
XU2851 XOR4D0BWP7T $PINS A3=n2440 VDD=VDD A4=n2439 VSS=VSS A1=n2442 A2=n2438
+ Z=n2456
XU2850 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<24> ZN=n2439
+ A2=n4580
XU2849 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<120> ZN=n2440
+ A2=SA_core_connect<31>
XU2847 FA1D0BWP7T $PINS CO=n2438 S=n2418 CI=n2435 B=n2436 VDD=VDD A=n2437
+ VSS=VSS
XU2846 FA1D0BWP7T $PINS CO=n2442 S=n2420 CI=n2432 B=n2433 VDD=VDD A=n2434
+ VSS=VSS
XU2845 XOR4D0BWP7T $PINS A3=n2430 VDD=VDD A4=n2429 VSS=VSS
+ A1=SA_core_shift_wire<39> A2=n2422 Z=n2457
XU2844 FA1D0BWP7T $PINS CO=n2429 S=n2432 CI=n2426 B=n2427 VDD=VDD A=n2428
+ VSS=VSS
XU2843 FA1D0BWP7T $PINS CO=n2430 S=n2434 CI=n2423 B=n2424 VDD=VDD A=n2425
+ VSS=VSS
XU2841 FA1D0BWP7T $PINS CO=n2422 S=n2436 CI=n2419 B=n2420 VDD=VDD A=n2421
+ VSS=VSS
XU2840 AO22D0BWP7T $PINS Z=SA_core_pe_1_1_N16 A2=n2418 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<30> VSS=VSS
XU2839 FA1D0BWP7T $PINS CO=n2435 S=n2393 CI=n2415 B=n2416 VDD=VDD A=n2417
+ VSS=VSS
XU2838 FA1D0BWP7T $PINS CO=n2419 S=n2417 CI=n2412 B=n2413 VDD=VDD A=n2414
+ VSS=VSS
XU2837 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2426 A2=SA_core_connect<24> A1=n4582
XU2836 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2427 A2=SA_core_connect<120>
+ A1=SA_core_connect<30>
XU2835 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3806 ZN=n2428 A2=n4585
XU2834 FA1D0BWP7T $PINS CO=n2433 S=n2416 CI=n2407 B=n2408 VDD=VDD A=n2409
+ VSS=VSS
XU2833 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3755 ZN=n2423 A2=n4813
XU2832 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2404 ZN=n2424 A2=n3759
XU2831 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3757 ZN=n2425 A2=n3801
XU2830 OA21D0BWP7T $PINS Z=n2443 A1=n2400 VDD=VDD A2=SA_core_shift_wire<38>
+ VSS=VSS B=n2450
XU2829 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<29>
+ A1=SA_core_connect<121> ZN=n2450 A3=SA_core_shift_wire<38>
XU2828 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4666 ZN=n2400 A2=n2398
XU2827 FA1D0BWP7T $PINS CO=n2445 S=n2413 CI=n2395 B=n2396 VDD=VDD A=n2397
+ VSS=VSS
XU2826 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2392 ZN=n2437 A2=n2393 A1=n2394
XU2825 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2391 A1=n2393 ZN=n2392 A2=n2394
XU2824 MOAI22D1BWP7T $PINS A2=n2390 A1=n4745 ZN=SA_core_pe_1_1_N15 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<29> VDD=VDD
XU2823 XNR3D0BWP7T $PINS A1=n2391 A2=n2394 VDD=VDD VSS=VSS A3=n2393 ZN=n2390
XU2822 FA1D0BWP7T $PINS CO=n2415 S=n2378 CI=n2387 B=n2388 VDD=VDD A=n2389
+ VSS=VSS
XU2821 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3801 ZN=n2407 A2=n3759
XU2820 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3757 ZN=n2408 A2=n4813
XU2819 FA1D0BWP7T $PINS CO=n2412 S=n2380 CI=n2384 B=n2385 VDD=VDD A=n2386
+ VSS=VSS
XU2818 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4585 ZN=n2395 A2=n4637
XU2817 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3755 ZN=n2396 A2=n3806
XU2816 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2398 ZN=n2397 A2=n4630
XU2815 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2414 B=n2444 A2=n2381
+ A1=SA_core_shift_wire<37>
XU2814 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<121> VDD=VDD A2=n4841
+ A3=SA_core_shift_wire<37> Z=n2444
XU2813 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4666 ZN=n2381 A2=n2404
XU2812 FA1D0BWP7T $PINS CO=n2394 S=n2375 CI=n2378 B=n2379 VDD=VDD A=n2380
+ VSS=VSS
XU2811 FA1D0BWP7T $PINS CO=n2391 S=n2374 CI=n2375 B=n4751 VDD=VDD A=n2377
+ VSS=VSS
XU2810 AO22D0BWP7T $PINS Z=SA_core_pe_1_1_N14 A2=n2374 A1=n2538 B1=n2097
+ VDD=VDD B2=SA_core_shift_wire<28> VSS=VSS
XU2809 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3757 ZN=n2387 A2=n3806
XU2808 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2388 B=n2409 A2=n2373
+ A1=SA_core_shift_wire<36>
XU2807 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<121> VDD=VDD
+ A2=SA_core_connect<27> A3=SA_core_shift_wire<36> Z=n2409
XU2806 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4666 ZN=n2373 A2=n3801
XU2805 FA1D0BWP7T $PINS CO=n2379 S=n2363 CI=n2370 B=n2371 VDD=VDD A=n2372
+ VSS=VSS
XU2804 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3755 ZN=n2384 A2=n4637
XU2803 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3759 ZN=n2385 A2=n4813
XU2802 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2404 ZN=n2386 A2=n4630
XU2800 MAOI222D1BWP7T $PINS ZN=n2369 C=n2366 B=n2367 VDD=VDD A=n2368 VSS=VSS
XU2799 INVD0BWP7T $PINS ZN=n2368 VSS=VSS VDD=VDD I=n2365
XU2798 FA1D0BWP7T $PINS CO=n2377 S=n2366 CI=n2362 B=n2363 VDD=VDD A=n2364
+ VSS=VSS
XU2797 MOAI22D0BWP7T $PINS A2=n4745 A1=n2361 ZN=SA_core_pe_1_1_N13 B1=n2097
+ VSS=VSS B2=SA_core_shift_wire<27> VDD=VDD
XU2796 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2366 A1=n2367 A3=n2365 Z=n2361
XU2795 FA1D0BWP7T $PINS CO=n2365 S=n2352 CI=n2358 B=n4203 VDD=VDD A=n2360
+ VSS=VSS
XU2794 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2362 B=n2389 A2=n2357
+ A1=SA_core_shift_wire<35>
XU2793 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<121> VDD=VDD
+ A2=SA_core_connect<26> A3=SA_core_shift_wire<35> Z=n2389
XU2792 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4666 ZN=n2357 A2=n4813
XU2791 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3757 ZN=n2370 A2=n4637
XU2790 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3801 ZN=n2371 A2=n4630
XU2789 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3759 ZN=n2372 A2=n3806
XU3006 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N32 A2=n2664
XU3005 INVD1BWP7T $PINS ZN=n2664 VSS=VSS VDD=VDD I=SA_col_3<6>
XU3004 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N31 A2=n4662
XU3002 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N30 A2=n3894
XU3000 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N29 A2=n3895
XU2998 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N28 A2=n3896
XU2996 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N27 A2=n4642
XU2994 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=SA_core_pe_0_3_N26 A2=n4685
XU2992 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4745 A2=n2585 A1=n2586
+ ZN=SA_core_pe_1_0_N17 C=n2583
XU2991 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2586 ZN=n2583 A2=n2585
XU2990 XNR4D0BWP7T $PINS A1=n2555 A2=n2581 ZN=n2585 A3=n2580 A4=n2579 VDD=VDD
+ VSS=VSS
XU2989 XNR4D0BWP7T $PINS A1=n2578 A2=n2577 ZN=n2579 A3=n2576 A4=n2575 VDD=VDD
+ VSS=VSS
XU2988 XNR4D0BWP7T $PINS A1=n2574 A2=n2570 ZN=n2575 A3=n2572 A4=n2571 VDD=VDD
+ VSS=VSS
XU2987 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_1<0> ZN=n2571
+ A2=SA_core_connect<103>
XU2986 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_1<7> ZN=n2572 A2=n4531
XU2984 FA1D0BWP7T $PINS CO=n2570 S=n2553 CI=n2567 B=n2568 VDD=VDD A=n2569
+ VSS=VSS
XU2983 FA1D0BWP7T $PINS CO=n2574 S=n2543 CI=n2564 B=n2565 VDD=VDD A=n2566
+ VSS=VSS
XU2982 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_1<2> ZN=n2576
+ A2=SA_core_connect<101>
XU2980 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2562 A1=n3851 ZN=n2560 A2=n3856
XU2979 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<100> ZN=n2562
+ A2=SA_row_1<3>
XU2977 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2558 A1=n4530 ZN=n2556 A2=n3855
XU2976 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<102> ZN=n2558
+ A2=SA_row_1<1>
XU2975 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_1<6> ZN=n2581
+ A2=SA_core_connect<97>
XU2973 FA1D0BWP7T $PINS CO=n2555 S=n2539 CI=n2552 B=n2553 VDD=VDD A=n4165
+ VSS=VSS
XU2972 XOR4D0BWP7T $PINS A3=n2550 VDD=VDD A4=n2549 VSS=VSS
+ A1=SA_core_shift_wire<31> A2=n2551 Z=n2586
XU2971 FA1D0BWP7T $PINS CO=n2549 S=n2545 CI=n2546 B=n2547 VDD=VDD A=n2548
+ VSS=VSS
XU2970 FA1D0BWP7T $PINS CO=n2550 S=n2569 CI=n2543 B=n2544 VDD=VDD A=n2545
+ VSS=VSS
XU2969 FA1D0BWP7T $PINS CO=n2551 S=n2568 CI=n2540 B=n2541 VDD=VDD A=n2542
+ VSS=VSS
XU2968 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_0_N16 A2=n2538 A1=n2539
XU2967 FA1D0BWP7T $PINS CO=n2552 S=n2514 CI=n2535 B=n2536 VDD=VDD A=n2537
+ VSS=VSS
XU2966 FA1D0BWP7T $PINS CO=n2567 S=n2536 CI=n2532 B=n2533 VDD=VDD A=n2534
+ VSS=VSS
XU2965 OA21D0BWP7T $PINS Z=n2540 A1=n2531 VDD=VDD A2=SA_core_shift_wire<30>
+ VSS=VSS B=n2580
XU2964 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_row_1<5> A1=SA_core_connect<97>
+ ZN=n2580 A3=SA_core_shift_wire<30>
XU2963 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4687 ZN=n2531 A2=n3855
XU2962 FA1D0BWP7T $PINS CO=n2541 S=n2534 CI=n2527 B=n2528 VDD=VDD A=n2529
+ VSS=VSS
XU2961 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2526 ZN=n2564 A2=n3858
XU2960 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3856 ZN=n2565 A2=n4530
XU2959 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3851 ZN=n2566 A2=n3857
XU2958 FA1D0BWP7T $PINS CO=n2544 S=n2537 CI=n2521 B=n2522 VDD=VDD A=n2523
+ VSS=VSS
XU2957 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2546 A2=SA_row_1<0>
+ A1=SA_core_connect<102>
XU2956 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2520 ZN=n2547 A2=n4532
XU2955 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4536 ZN=n2548 A2=n2517
XU2953 MAOI222D1BWP7T $PINS ZN=n2516 C=n2513 B=n2514 VDD=VDD A=n2515 VSS=VSS
XU2952 AOI21D0BWP7T $PINS VSS=VSS A2=n2512 VDD=VDD A1=n2515 B=n2511
+ ZN=SA_core_pe_1_0_N15
XU2951 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2538 A1=n2515 ZN=n2511 A2=n2512
XU2950 MAOI22D0BWP7T $PINS A2=n2513 ZN=n2512 A1=n2514 B2=n2514 VDD=VDD B1=n2513
+ VSS=VSS
XU2949 FA1D0BWP7T $PINS CO=n2513 S=n2497 CI=n2508 B=n2509 VDD=VDD A=n2510
+ VSS=VSS
XU2948 FA1D0BWP7T $PINS CO=n2535 S=n2508 CI=n2505 B=n2506 VDD=VDD A=n2507
+ VSS=VSS
XU2947 FA1D0BWP7T $PINS CO=n2532 S=n2510 CI=n2502 B=n2503 VDD=VDD A=n2504
+ VSS=VSS
XU2946 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2533 B=n2542 A2=n2501
+ A1=SA_core_shift_wire<29>
XU2945 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<97> VDD=VDD A2=SA_row_1<4>
+ A3=SA_core_shift_wire<29> Z=n2542
XU2944 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4687 ZN=n2501 A2=n3856
XU2943 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2517 ZN=n2527 A2=n4643
XU2942 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2526 ZN=n2528 A2=n4536
XU2941 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3855 ZN=n2529 A2=n4532
XU2940 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3857 ZN=n2521 A2=n4530
XU2939 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3851 ZN=n2522 A2=n3858
XU2938 FA1D0BWP7T $PINS CO=n2515 S=n2496 CI=n2497 B=n4180 VDD=VDD A=n2499
+ VSS=VSS
XU2937 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_1_0_N14 A2=n2538 A1=n2496
XU2936 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3851 ZN=n2505 A2=n4536
XU2935 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2506 B=n2523 A2=n2495
+ A1=SA_core_shift_wire<28>
XU2934 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<97> VDD=VDD A2=SA_row_1<3>
+ A3=SA_core_shift_wire<28> Z=n2523
XU2933 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4687 ZN=n2495 A2=n3857
XU2932 FA1D0BWP7T $PINS CO=n2509 S=n2487 CI=n2492 B=n2493 VDD=VDD A=n2494
+ VSS=VSS
XU2931 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2526 ZN=n2502 A2=n4643
XU2930 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4530 ZN=n2503 A2=n3858
XU2929 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3856 ZN=n2504 A2=n4532
XU2927 FA1D0BWP7T $PINS CO=n2499 S=n2483 CI=n2486 B=n2487 VDD=VDD A=n2488
+ VSS=VSS
XU2926 AOI21D1BWP7T $PINS VSS=VSS A2=n2485 VDD=VDD A1=n2491 B=n2484
+ ZN=SA_core_pe_1_0_N13
XU2925 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2538 A1=n2491 ZN=n2484 A2=n2485
XU2923 INVD0BWP7T $PINS ZN=n2490 VSS=VSS VDD=VDD I=n2483
XU2922 INVD0BWP7T $PINS ZN=n2489 VSS=VSS VDD=VDD I=n2482
XU2921 FA1D0BWP7T $PINS CO=n2482 S=n2472 CI=n2479 B=n2480 VDD=VDD A=n2481
+ VSS=VSS
XU2920 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2486 B=n2507 A2=n2478
+ A1=SA_core_shift_wire<27>
XU2919 AN3D1BWP7T $PINS VSS=VSS A1=SA_core_connect<97> VDD=VDD A2=SA_row_1<2>
+ A3=SA_core_shift_wire<27> Z=n2507
XU2918 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4687 ZN=n2478 A2=n3858
XU2917 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3851 ZN=n2492 A2=n4643
XU2916 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3857 ZN=n2493 A2=n4532
XU2915 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4530 ZN=n2494 A2=n4536
XU2914 INVD0BWP7T $PINS ZN=n2488 VSS=VSS VDD=VDD I=n2477
XU2913 FA1D0BWP7T $PINS CO=n2491 S=n2473 CI=n2474 B=n2475 VDD=VDD A=n2476
+ VSS=VSS
XU2912 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2473 ZN=SA_core_pe_1_0_N12 A2=n4745
XU2911 INVD0BWP7T $PINS ZN=n2474 VSS=VSS VDD=VDD I=n2472
XU2910 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3858 ZN=n2479 A2=n4532
XU2909 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4687 ZN=n2480 A2=n4536
XU2907 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2477 A1=SA_core_shift_wire<26>
+ ZN=n2476 A2=n2468
XU2906 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_row_1<0> A1=SA_core_connect<98>
+ ZN=n2477 A3=SA_core_shift_wire<26>
XU2905 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4530 ZN=n2468 A2=n4643
XU2904 AOI21D0BWP7T $PINS VSS=VSS A2=n2467 VDD=VDD A1=n2470 B=n2466
+ ZN=SA_core_pe_1_0_N11
XU2903 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2538 A1=n2470 ZN=n2466 A2=n2467
XU2902 MAOI22D0BWP7T $PINS A2=n2469 ZN=n2467 A1=n2471 B2=n2471 VDD=VDD B1=n2469
+ VSS=VSS
XU3121 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N28 A2=n4673
XU3119 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N27 A2=n4633
XU3117 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N26 A2=n4683
XU3114 XNR4D0BWP7T $PINS A1=n2710 A2=n2709 ZN=n2711 A3=n2708 A4=n2707 VDD=VDD
+ VSS=VSS
XU3113 XNR4D0BWP7T $PINS A1=n2706 A2=n2705 ZN=n2707 A3=n2704 A4=n2703 VDD=VDD
+ VSS=VSS
XU3112 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4641 ZN=n2704
+ A2=SA_core_connect<22>
XU3111 XOR4D0BWP7T $PINS A3=n2700 VDD=VDD A4=n2699 VSS=VSS A1=n2702 A2=n2701
+ Z=n2705
XU3110 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<6> ZN=n2699
+ A2=SA_core_connect<17>
XU3109 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<21> ZN=n2700
+ A2=SA_col_3<2>
XU3108 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<4> ZN=n2701 A2=n4576
XU3107 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<3> ZN=n2702
+ A2=SA_core_connect<20>
XU3106 FA1D0BWP7T $PINS CO=n2706 S=n2674 CI=n2696 B=n2697 VDD=VDD A=n2698
+ VSS=VSS
XU3105 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<5> ZN=n2708
+ A2=SA_core_connect<18>
XU3104 XOR4D0BWP7T $PINS A3=n2693 VDD=VDD A4=n2692 VSS=VSS A1=n2695 A2=n2691
+ Z=n2709
XU3103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<7> ZN=n2692
+ A2=SA_core_connect<16>
XU3102 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_3<0> ZN=n2693
+ A2=SA_core_connect<23>
XU3100 FA1D0BWP7T $PINS CO=n2691 S=n2671 CI=n2688 B=n2689 VDD=VDD A=n2690
+ VSS=VSS
XU3099 FA1D0BWP7T $PINS CO=n2695 S=n2673 CI=n2685 B=n2686 VDD=VDD A=n2687
+ VSS=VSS
XU3098 XOR4D0BWP7T $PINS A3=n2683 VDD=VDD A4=n2682 VSS=VSS A1=n2675
+ A2=SA_core_output_row_0<7> Z=n2710
XU3097 FA1D0BWP7T $PINS CO=n2682 S=n2685 CI=n2679 B=n2680 VDD=VDD A=n2681
+ VSS=VSS
XU3096 FA1D0BWP7T $PINS CO=n2683 S=n2687 CI=n2676 B=n2677 VDD=VDD A=n2678
+ VSS=VSS
XU3094 FA1D0BWP7T $PINS CO=n2675 S=n2689 CI=n2672 B=n2673 VDD=VDD A=n2674
+ VSS=VSS
XU3093 AO22D0BWP7T $PINS Z=SA_core_pe_0_3_N16 A2=n2671 A1=n4742 B1=n2590
+ VDD=VDD B2=SA_core_shift_wire<22> VSS=VSS
XU3092 FA1D0BWP7T $PINS CO=n2688 S=n2646 CI=n2668 B=n2669 VDD=VDD A=n2670
+ VSS=VSS
XU3091 FA1D0BWP7T $PINS CO=n2672 S=n2670 CI=n2665 B=n2666 VDD=VDD A=n2667
+ VSS=VSS
XU3090 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2664 ZN=n2679 A2=n4691
XU3089 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2680 A2=SA_col_3<0>
+ A1=SA_core_connect<22>
XU3088 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3750 ZN=n2681 A2=n4662
XU3087 FA1D0BWP7T $PINS CO=n2686 S=n2669 CI=n2658 B=n2659 VDD=VDD A=n2660
+ VSS=VSS
XU3086 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3894 ZN=n2676 A2=n3748
XU3085 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2655 ZN=n2677 A2=n3896
XU3084 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3895 ZN=n2678 A2=n4577
XU3083 OA21D0BWP7T $PINS Z=n2696 A1=n2651 VDD=VDD A2=SA_core_output_row_0<6>
+ VSS=VSS B=n2703
XU3082 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<21> A1=n4641
+ ZN=n2703 A3=SA_core_output_row_0<6>
XU3081 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2651 A2=n4641 A1=SA_core_connect<21>
XU3080 FA1D0BWP7T $PINS CO=n2698 S=n2666 CI=n2648 B=n2649 VDD=VDD A=n2650
+ VSS=VSS
XU3079 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2645 ZN=n2690 A2=n2646 A1=n2647
XU3078 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2644 A1=n2646 ZN=n2645 A2=n2647
XU3077 MOAI22D1BWP7T $PINS A2=n2643 A1=n4743 ZN=SA_core_pe_0_3_N15 B1=n2590
+ VSS=VSS B2=n4598 VDD=VDD
XU3076 XNR3D0BWP7T $PINS A1=n2644 A2=n2647 VDD=VDD VSS=VSS A3=n2646 ZN=n2643
XU3075 FA1D0BWP7T $PINS CO=n2668 S=n2631 CI=n2640 B=n2641 VDD=VDD A=n2642
+ VSS=VSS
XU3074 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4577 ZN=n2658 A2=n3896
XU3073 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3895 ZN=n2659 A2=n3748
XU3072 FA1D0BWP7T $PINS CO=n2665 S=n2633 CI=n2637 B=n2638 VDD=VDD A=n2639
+ VSS=VSS
XU3071 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4662 ZN=n2648 A2=n4691
XU3070 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3894 ZN=n2649 A2=n3750
XU3069 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2650 A2=SA_col_3<0>
+ A1=SA_core_connect<21>
XU3067 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2697 A1=n4642 A3=n3766 A2=n2655
XU3066 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4641 ZN=n2635
+ A2=SA_core_connect<20>
XU3064 FA1D0BWP7T $PINS CO=n2647 S=n2628 CI=n2631 B=n2632 VDD=VDD A=n2633
+ VSS=VSS
XU3063 FA1D0BWP7T $PINS CO=n2644 S=n2627 CI=n2628 B=n4752 VDD=VDD A=n2630
+ VSS=VSS
XU3062 AO22D0BWP7T $PINS Z=SA_core_pe_0_3_N14 A2=n2627 A1=n4742 B1=n2590
+ VDD=VDD B2=SA_core_shift_wire<20> VSS=VSS
XU3061 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3895 ZN=n2640 A2=n3750
XU3060 AOI21D0BWP7T $PINS VSS=VSS A2=n2625 VDD=VDD A1=n3767 B=n2660 ZN=n2641
XU3058 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4641 ZN=n2625 A2=n4576
XU3056 FA1D0BWP7T $PINS CO=n2632 S=n2614 CI=n2622 B=n2623 VDD=VDD A=n2624
+ VSS=VSS
XU3055 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3894 ZN=n2637 A2=n4691
XU3054 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3896 ZN=n2638 A2=n3748
XU3053 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2655 ZN=n2639 A2=n4685
XU3052 CKND0BWP7T $PINS ZN=n2655 VSS=VSS VDD=VDD I=SA_core_connect<20>
XU3050 MAOI222D1BWP7T $PINS ZN=n2620 C=n2617 B=n2618 VDD=VDD A=n2619 VSS=VSS
XU3049 INVD0BWP7T $PINS ZN=n2619 VSS=VSS VDD=VDD I=n2616
XU3048 FA1D0BWP7T $PINS CO=n2630 S=n2617 CI=n2613 B=n2614 VDD=VDD A=n2615
+ VSS=VSS
XU3045 FA1D0BWP7T $PINS CO=n2616 S=n2602 CI=n2609 B=n2610 VDD=VDD A=n2611
+ VSS=VSS
XU3044 AOI21D0BWP7T $PINS VSS=VSS A2=n2607 VDD=VDD A1=n3768 B=n2642 ZN=n2613
XU3042 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4641 ZN=n2607
+ A2=SA_core_connect<18>
XU3040 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3895 ZN=n2622 A2=n4691
XU3039 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4577 ZN=n2623 A2=n4685
XU3037 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3896 ZN=n2624 A2=n3750
XU3036 INVD0BWP7T $PINS ZN=n2615 VSS=VSS VDD=VDD I=n2606
XU3035 FA1D0BWP7T $PINS CO=n2618 S=n2601 CI=n2603 B=n2604 VDD=VDD A=n2605
+ VSS=VSS
XU3034 MOAI22D0BWP7T $PINS A2=n4743 A1=n2602 ZN=SA_core_pe_0_3_N12 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<18> VDD=VDD
XU3033 INVD0BWP7T $PINS ZN=n2609 VSS=VSS VDD=VDD I=n2601
XU3032 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3748 ZN=n2603 A2=n4685
XU3030 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4642 ZN=n2604 A2=n3750
XU3027 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<16> A1=SA_col_3<2>
+ ZN=n2606 A3=SA_core_output_row_0<2>
XU3026 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3896 ZN=n2597 A2=n4691
XU3025 MOAI22D0BWP7T $PINS A2=n2596 A1=n4743 ZN=SA_core_pe_0_3_N11 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<17> VDD=VDD
XU3023 XNR3D0BWP7T $PINS A1=n2599 A2=n2600 VDD=VDD VSS=VSS A3=n2598 ZN=n2596
XU3022 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3750 ZN=n2598 A2=n4685
XU3020 INVD0BWP7T $PINS ZN=n2600 VSS=VSS VDD=VDD I=n2594
XU3016 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4641 ZN=n2593
+ A2=SA_core_connect<16>
XU3015 MOAI22D0BWP7T $PINS A2=n2591 A1=n4743 ZN=SA_core_pe_0_3_N10 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<16> VDD=VDD
XU3009 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4685 ZN=n2587 A2=n4691
XU3007 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_3_N33 A2=n4731
+ A1=SA_col_3<7>
XU3228 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4682 ZN=n2814
+ A2=SA_core_connect<15>
XU3226 FA1D0BWP7T $PINS CO=n2812 S=n2792 CI=n2809 B=n2810 VDD=VDD A=n2811
+ VSS=VSS
XU3225 FA1D0BWP7T $PINS CO=n2816 S=n2794 CI=n2806 B=n2807 VDD=VDD A=n2808
+ VSS=VSS
XU3224 XOR4D0BWP7T $PINS A3=n2804 VDD=VDD A4=n2803 VSS=VSS
+ A1=SA_core_shift_wire<23> A2=n2796 Z=n2831
XU3223 FA1D0BWP7T $PINS CO=n2803 S=n2806 CI=n2800 B=n2801 VDD=VDD A=n2802
+ VSS=VSS
XU3222 FA1D0BWP7T $PINS CO=n2804 S=n2808 CI=n2797 B=n2798 VDD=VDD A=n2799
+ VSS=VSS
XU3220 FA1D0BWP7T $PINS CO=n2796 S=n2810 CI=n2793 B=n2794 VDD=VDD A=n2795
+ VSS=VSS
XU3219 AO22D0BWP7T $PINS Z=SA_core_pe_0_2_N16 A2=n2792 A1=n4742 B1=n2590
+ VDD=VDD B2=SA_core_shift_wire<14> VSS=VSS
XU3218 FA1D0BWP7T $PINS CO=n2809 S=n2765 CI=n2789 B=n2790 VDD=VDD A=n2791
+ VSS=VSS
XU3217 FA1D0BWP7T $PINS CO=n2793 S=n2791 CI=n2786 B=n2787 VDD=VDD A=n2788
+ VSS=VSS
XU3216 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3887 ZN=n2800 A2=n4579
XU3215 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2801 A2=n4682 A1=SA_core_connect<14>
XU3214 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3751 ZN=n2802 A2=n4659
XU3213 FA1D0BWP7T $PINS CO=n2807 S=n2790 CI=n2779 B=n2780 VDD=VDD A=n2781
+ VSS=VSS
XU3212 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4661 ZN=n2797 A2=n3749
XU3211 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4575 ZN=n2798 A2=n4673
XU3210 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3890 ZN=n2799 A2=n3747
XU3209 OA21D0BWP7T $PINS Z=n2817 A1=n2772 VDD=VDD A2=SA_core_shift_wire<22>
+ VSS=VSS B=n2824
XU3208 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<13> A1=SA_col_2<1>
+ ZN=n2824 A3=SA_core_shift_wire<22>
XU3207 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4633 ZN=n2772 A2=n2770
XU3206 FA1D0BWP7T $PINS CO=n2819 S=n2787 CI=n2767 B=n2768 VDD=VDD A=n2769
+ VSS=VSS
XU3205 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2764 ZN=n2811 A2=n2765 A1=n2766
XU3204 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2763 A1=n2765 ZN=n2764 A2=n2766
XU3203 MOAI22D1BWP7T $PINS A2=n2762 A1=n4743 ZN=SA_core_pe_0_2_N15 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<13> VDD=VDD
XU3202 XNR3D0BWP7T $PINS A1=n2763 A2=n2766 VDD=VDD VSS=VSS A3=n2765 ZN=n2762
XU3201 FA1D0BWP7T $PINS CO=n2789 S=n2751 CI=n2759 B=n2760 VDD=VDD A=n2761
+ VSS=VSS
XU3200 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3747 ZN=n2779 A2=n4673
XU3199 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3890 ZN=n2780 A2=n3749
XU3198 FA1D0BWP7T $PINS CO=n2786 S=n2753 CI=n2756 B=n2757 VDD=VDD A=n2758
+ VSS=VSS
XU3197 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4659 ZN=n2767 A2=n4579
XU3196 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4661 ZN=n2768 A2=n3751
XU3195 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2770 ZN=n2769 A2=n4683
XU3194 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2788 B=n2818 A2=n2754 A1=n4598
XU3193 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_2<1> VDD=VDD A2=n4840 A3=n4598
+ Z=n2818
XU3192 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4633 ZN=n2754 A2=n4575
XU3191 FA1D0BWP7T $PINS CO=n2766 S=n2748 CI=n2751 B=n2752 VDD=VDD A=n2753
+ VSS=VSS
XU3190 FA1D0BWP7T $PINS CO=n2763 S=n2747 CI=n2748 B=n4799 VDD=VDD A=n2750
+ VSS=VSS
XU3189 AO22D0BWP7T $PINS Z=SA_core_pe_0_2_N14 A2=n2747 A1=n4742 B1=n2590
+ VDD=VDD B2=SA_core_shift_wire<12> VSS=VSS
XU3188 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3890 ZN=n2759 A2=n3751
XU3187 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2760 B=n2781 A2=n2746
+ A1=SA_core_shift_wire<20>
XU3186 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_2<1> VDD=VDD A2=SA_core_connect<11>
+ A3=SA_core_shift_wire<20> Z=n2781
XU3185 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4633 ZN=n2746 A2=n3747
XU3184 FA1D0BWP7T $PINS CO=n2752 S=n2736 CI=n2743 B=n2744 VDD=VDD A=n2745
+ VSS=VSS
XU3183 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4661 ZN=n2756 A2=n4579
XU3182 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4673 ZN=n2757 A2=n3749
XU3181 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4575 ZN=n2758 A2=n4683
XU3179 MAOI222D1BWP7T $PINS ZN=n2742 C=n2739 B=n2740 VDD=VDD A=n2741 VSS=VSS
XU3178 INVD0BWP7T $PINS ZN=n2741 VSS=VSS VDD=VDD I=n2738
XU3177 FA1D0BWP7T $PINS CO=n2750 S=n2739 CI=n2735 B=n2736 VDD=VDD A=n2737
+ VSS=VSS
XU3176 MOAI22D0BWP7T $PINS A2=n4743 A1=n2734 ZN=SA_core_pe_0_2_N13 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<11> VDD=VDD
XU3175 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2739 A1=n2740 A3=n2738 Z=n2734
XU3174 FA1D0BWP7T $PINS CO=n2738 S=n2725 CI=n2731 B=n4209 VDD=VDD A=n2733
+ VSS=VSS
XU3172 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_2<1> VDD=VDD A2=n4814
+ A3=SA_core_shift_wire<19> Z=n2761
XU3171 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4633 ZN=n2730 A2=n3749
XU3170 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3890 ZN=n2743 A2=n4579
XU3169 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3747 ZN=n2744 A2=n4683
XU3168 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4673 ZN=n2745 A2=n3751
XU3167 INVD0BWP7T $PINS ZN=n2737 VSS=VSS VDD=VDD I=n2729
XU3166 FA1D0BWP7T $PINS CO=n2740 S=n2724 CI=n2726 B=n2727 VDD=VDD A=n2728
+ VSS=VSS
XU3165 MOAI22D0BWP7T $PINS A2=n4743 A1=n2725 ZN=SA_core_pe_0_2_N12 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<10> VDD=VDD
XU3164 INVD0BWP7T $PINS ZN=n2731 VSS=VSS VDD=VDD I=n2724
XU3163 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3749 ZN=n2726 A2=n4683
XU3162 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4633 ZN=n2727 A2=n3751
XU3160 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2729 A1=SA_core_shift_wire<18>
+ ZN=n2733 A2=n2720
XU3159 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4578 A1=n4672 ZN=n2729
+ A3=SA_core_shift_wire<18>
XU3158 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4673 ZN=n2720 A2=n4579
XU3157 MOAI22D0BWP7T $PINS A2=n2719 A1=n4743 ZN=SA_core_pe_0_2_N11 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<9> VDD=VDD
XU3156 XNR3D0BWP7T $PINS A1=n4450 A2=n2723 VDD=VDD VSS=VSS A3=n2721 ZN=n2719
XU3155 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3751 ZN=n2721 A2=n4683
XU3154 INVD0BWP7T $PINS ZN=n2723 VSS=VSS VDD=VDD I=n2718
XU3151 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_2<1> ZN=n2716 A2=n4578
XU3149 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2715 ZN=SA_core_pe_0_2_N10
+ A2=SA_core_shift_wire<8> A1=n2590
XU3148 OAI211D0BWP7T $PINS A2=n2714 ZN=n2715 A1=SA_core_shift_wire<16> B=n4742
+ VDD=VDD C=n2718 VSS=VSS
XU3147 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4578 A1=n4682 ZN=n2718
+ A3=SA_core_shift_wire<16>
XU3146 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4683 ZN=n2714 A2=n4579
XU3145 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_2_N25 A2=n4731
+ A1=SA_core_connect<15>
XU3144 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_2_N24 A2=n4731
+ A1=SA_core_connect<14>
XU3143 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N23 A2=n2770
XU3141 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N22 A2=n4575
XU3139 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N21 A2=n3747
XU3137 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N20 A2=n3749
XU3135 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N19 A2=n3751
XU3133 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N18 A2=n4579
XU3131 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_2_N33 A2=n4731
+ A1=SA_col_2<7>
XU3130 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N32 A2=n3887
XU3128 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N31 A2=n4659
XU3126 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N30 A2=n4661
XU3124 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_2_N29 A2=n3890
XU3339 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3849 ZN=n2927 A2=n3881
XU3338 FA1D0BWP7T $PINS CO=n2932 S=n2914 CI=n2903 B=n2904 VDD=VDD A=n2905
+ VSS=VSS
XU3337 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3882 ZN=n2922 A2=n3848
XU3336 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4527 ZN=n2923 A2=n3884
XU3335 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3883 ZN=n2924 A2=n3847
XU3334 OA21D0BWP7T $PINS Z=n2942 A1=n2896 VDD=VDD A2=SA_core_shift_wire<14>
+ VSS=VSS B=n2949
XU3333 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<5> A1=SA_col_1<1>
+ ZN=n2949 A3=SA_core_shift_wire<14>
XU3332 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4692 ZN=n2896 A2=n3845
XU3331 FA1D0BWP7T $PINS CO=n2944 S=n2911 CI=n2891 B=n2892 VDD=VDD A=n2893
+ VSS=VSS
XU3330 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2888 ZN=n2936 A2=n2889 A1=n2890
XU3329 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2887 A1=n2889 ZN=n2888 A2=n2890
XU3327 XNR3D0BWP7T $PINS A1=n2887 A2=n2890 VDD=VDD VSS=VSS A3=n2889 ZN=n2886
XU3326 FA1D0BWP7T $PINS CO=n2913 S=n2875 CI=n2883 B=n2884 VDD=VDD A=n2885
+ VSS=VSS
XU3325 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3847 ZN=n2903 A2=n3884
XU3324 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3883 ZN=n2904 A2=n3848
XU3323 FA1D0BWP7T $PINS CO=n2910 S=n2877 CI=n2880 B=n2881 VDD=VDD A=n2882
+ VSS=VSS
XU3322 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3881 ZN=n2891 A2=n4647
XU3321 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3882 ZN=n2892 A2=n3849
XU3320 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3845 ZN=n2893 A2=n4634
XU3318 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_1<1> VDD=VDD A2=n4526
+ A3=SA_core_shift_wire<13> Z=n2943
XU3317 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4692 ZN=n2878 A2=n4527
XU3316 FA1D0BWP7T $PINS CO=n2890 S=n2872 CI=n2875 B=n2876 VDD=VDD A=n2877
+ VSS=VSS
XU3315 FA1D0BWP7T $PINS CO=n2887 S=n2871 CI=n2872 B=n4754 VDD=VDD A=n2874
+ VSS=VSS
XU3314 AO22D0BWP7T $PINS Z=SA_core_pe_0_1_N14 A2=n2871 A1=n4742 B1=n2590
+ VDD=VDD B2=SA_core_shift_wire<4> VSS=VSS
XU3313 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3883 ZN=n2883 A2=n3849
XU3312 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2884 B=n2905 A2=n2870
+ A1=SA_core_shift_wire<12>
XU3311 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_1<1> VDD=VDD A2=SA_core_connect<3>
+ A3=SA_core_shift_wire<12> Z=n2905
XU3310 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4692 ZN=n2870 A2=n3847
XU3309 FA1D0BWP7T $PINS CO=n2876 S=n2860 CI=n2867 B=n2868 VDD=VDD A=n2869
+ VSS=VSS
XU3308 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3882 ZN=n2880 A2=n4647
XU3307 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3884 ZN=n2881 A2=n3848
XU3306 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4527 ZN=n2882 A2=n4634
XU3303 INVD0BWP7T $PINS ZN=n2865 VSS=VSS VDD=VDD I=n2862
XU3302 FA1D0BWP7T $PINS CO=n2874 S=n2863 CI=n2859 B=n2860 VDD=VDD A=n3916
+ VSS=VSS
XU3301 MOAI22D0BWP7T $PINS A2=n4743 A1=n2858 ZN=SA_core_pe_0_1_N13 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<3> VDD=VDD
XU3300 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2863 A1=n2864 A3=n2862 Z=n2858
XU3299 FA1D0BWP7T $PINS CO=n2862 S=n2849 CI=n2855 B=n4211 VDD=VDD A=n2857
+ VSS=VSS
XU3298 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2859 B=n2885 A2=n2854
+ A1=SA_core_shift_wire<11>
XU3297 AN3D1BWP7T $PINS VSS=VSS A1=SA_col_1<1> VDD=VDD A2=SA_core_connect<2>
+ A3=SA_core_shift_wire<11> Z=n2885
XU3296 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4692 ZN=n2854 A2=n3848
XU3295 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3883 ZN=n2867 A2=n4647
XU3294 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3847 ZN=n2868 A2=n4634
XU3293 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3884 ZN=n2869 A2=n3849
XU3291 FA1D0BWP7T $PINS CO=n2864 S=n2848 CI=n2850 B=n2851 VDD=VDD A=n2852
+ VSS=VSS
XU3290 MOAI22D1BWP7T $PINS A2=n4743 A1=n2849 ZN=SA_core_pe_0_1_N12 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<2> VDD=VDD
XU3289 INVD0BWP7T $PINS ZN=n2855 VSS=VSS VDD=VDD I=n2848
XU3288 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3848 ZN=n2850 A2=n4634
XU3287 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4692 ZN=n2851 A2=n3849
XU3284 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<0> A1=SA_col_1<2>
+ ZN=n2853 A3=SA_core_shift_wire<10>
XU3283 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3884 ZN=n2844 A2=n4647
XU3281 XNR3D0BWP7T $PINS A1=n4418 A2=n2847 VDD=VDD VSS=VSS A3=n2845 ZN=n2843
XU3280 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3849 ZN=n2845 A2=n4634
XU3279 INVD0BWP7T $PINS ZN=n2847 VSS=VSS VDD=VDD I=n2842
XU3277 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2852 A1=n4692 A3=n2841 A2=n4647
XU3276 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<1> ZN=n2840
+ A2=SA_core_connect<0>
XU3275 INVD0BWP7T $PINS ZN=n2841 VSS=VSS VDD=VDD I=SA_core_shift_wire<9>
XU3274 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2838 ZN=SA_core_pe_0_1_N10
+ A2=SA_core_shift_wire<0> A1=n2590
XU3273 OAI211D0BWP7T $PINS A2=n2837 ZN=n2838 A1=SA_core_shift_wire<8> B=n4742
+ VDD=VDD C=n2842 VSS=VSS
XU3272 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=SA_core_connect<0> A1=SA_col_1<0>
+ ZN=n2842 A3=SA_core_shift_wire<8>
XU3271 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4634 ZN=n2837 A2=n4647
XU3270 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_1_N25 A2=n4731
+ A1=SA_core_connect<7>
XU3269 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_1_N24 A2=n4731 A1=n4817
XU3268 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N23 A2=n3845
XU3264 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N21 A2=n3847
XU3260 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N19 A2=n3849
XU3258 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N18 A2=n4647
XU3256 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=SA_core_pe_0_1_N33 A2=n4731
+ A1=SA_col_1<7>
XU3255 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N32 A2=n3880
XU3253 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N31 A2=n3881
XU3251 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N30 A2=n3882
XU3249 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N29 A2=n3883
XU3245 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N27 A2=n4692
XU3243 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4726 ZN=SA_core_pe_0_1_N26 A2=n4634
XU3241 MOAI22D0BWP7T $PINS A2=n2832 A1=n4743 ZN=SA_core_pe_0_2_N17 B1=n2590
+ VSS=VSS B2=SA_core_shift_wire<15> VDD=VDD
XU3240 XNR4D0BWP7T $PINS A1=n2831 A2=n2830 ZN=n2832 A3=n2829 A4=n2828 VDD=VDD
+ VSS=VSS
XU3239 XNR4D0BWP7T $PINS A1=n2827 A2=n2826 ZN=n2828 A3=n2825 A4=n2824 VDD=VDD
+ VSS=VSS
XU3238 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_2<1> ZN=n2825
+ A2=SA_core_connect<14>
XU3237 XOR4D0BWP7T $PINS A3=n2821 VDD=VDD A4=n2820 VSS=VSS A1=n2823 A2=n2822
+ Z=n2826
XU3236 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_2<6> ZN=n2820
+ A2=SA_core_connect<9>
XU3235 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<13> ZN=n2821
+ A2=n4672
XU3234 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4660 ZN=n2822
+ A2=SA_core_connect<11>
XU3233 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_2<3> ZN=n2823 A2=n4840
XU3232 FA1D0BWP7T $PINS CO=n2827 S=n2795 CI=n2817 B=n2818 VDD=VDD A=n2819
+ VSS=VSS
XU3231 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4658 ZN=n2829 A2=n4814
XU3230 XOR4D0BWP7T $PINS A3=n2814 VDD=VDD A4=n2813 VSS=VSS A1=n2816 A2=n2812
+ Z=n2830
XU3229 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_2<7> ZN=n2813 A2=n4578
XU3453 AO22D0BWP7T $PINS Z=SA_core_pe_3_3_N16 A2=n3043 A1=n4749 B1=n4835
+ VDD=VDD B2=n3084 VSS=VSS
XU3452 FA1D0BWP7T $PINS CO=n3061 S=n3022 CI=n3040 B=n3041 VDD=VDD A=n3042
+ VSS=VSS
XU3451 FA1D0BWP7T $PINS CO=n3045 S=n3042 CI=n3037 B=n3038 VDD=VDD A=n3039
+ VSS=VSS
XU3450 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3052 A2=n4820
+ A1=SA_core_connect<190>
XU3449 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3053 A2=SA_core_connect<184>
+ A1=SA_core_connect<94>
XU3448 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3054 A2=n4570
+ A1=SA_core_connect<189>
XU3447 FA1D0BWP7T $PINS CO=n3059 S=n3041 CI=n3034 B=n3035 VDD=VDD A=n3036
+ VSS=VSS
XU3446 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3786 ZN=n3049 A2=n4567
XU3445 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3031 ZN=n3050 A2=n3791
XU3444 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3788 ZN=n3051 A2=n4561
XU3443 OA21D0BWP7T $PINS Z=n3069 A1=n3027 VDD=VDD A2=SA_core_output_row_3<6>
+ VSS=VSS B=n3076
XU3442 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4555 A1=SA_core_connect<185>
+ ZN=n3076 A3=SA_core_output_row_3<6>
XU3441 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3027 A2=SA_core_connect<185>
+ A1=n4555
XU3440 FA1D0BWP7T $PINS CO=n3071 S=n3038 CI=n3024 B=n3025 VDD=VDD A=n3026
+ VSS=VSS
XU3439 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3021 ZN=n3063 A2=n3022 A1=n3023
XU3438 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3020 A1=n3022 ZN=n3021 A2=n3023
XU3436 XNR3D0BWP7T $PINS A1=n3020 A2=n3023 VDD=VDD VSS=VSS A3=n3022 ZN=n3019
XU3435 FA1D0BWP7T $PINS CO=n3040 S=n3004 CI=n3014 B=n3015 VDD=VDD A=n3016
+ VSS=VSS
XU3434 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4561 ZN=n3034 A2=n3791
XU3433 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3788 ZN=n3035 A2=n4567
XU3432 FA1D0BWP7T $PINS CO=n3037 S=n3006 CI=n3011 B=n3012 VDD=VDD A=n3013
+ VSS=VSS
XU3431 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3024 A2=n4820
+ A1=SA_core_connect<189>
XU3430 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3786 ZN=n3025 A2=n4571
XU3429 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3026 A2=SA_core_connect<184>
+ A1=n4555
XU3428 AOI21D0BWP7T $PINS VSS=VSS A2=n3008 VDD=VDD A1=n3839 B=n3070 ZN=n3039
XU3427 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3070 A1=n4628 A3=n3839 A2=n3031
XU3426 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<185> ZN=n3008
+ A2=SA_core_connect<92>
XU3424 FA1D0BWP7T $PINS CO=n3023 S=n3001 CI=n3004 B=n3005 VDD=VDD A=n3006
+ VSS=VSS
XU3423 FA1D0BWP7T $PINS CO=n3020 S=n2999 CI=n3001 B=n4178 VDD=VDD A=n3003
+ VSS=VSS
XU3422 MOAI22D0BWP7T $PINS A2=n3000 A1=n4746 ZN=SA_core_pe_3_3_N14 B1=n4749
+ VSS=VSS B2=n2999 VDD=VDD
XU3421 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3788 ZN=n3014 A2=n4571
XU3418 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<185> ZN=n2997
+ A2=n4560
XU3416 FA1D0BWP7T $PINS CO=n3005 S=n2985 CI=n2994 B=n2995 VDD=VDD A=n2996
+ VSS=VSS
XU3415 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3786 ZN=n3011 A2=n4676
XU3413 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3791 ZN=n3012 A2=n4567
XU3412 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3031 ZN=n3013 A2=n3797
XU3411 INVD0BWP7T $PINS ZN=n3031 VSS=VSS VDD=VDD I=SA_core_connect<92>
XU3408 INVD0BWP7T $PINS ZN=n2990 VSS=VSS VDD=VDD I=n2987
XU3407 FA1D0BWP7T $PINS CO=n3003 S=n2988 CI=n2984 B=n2985 VDD=VDD A=n2986
+ VSS=VSS
XU3405 XOR3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2988 A1=n2989 A3=n2987 Z=n2983
XU3404 FA1D0BWP7T $PINS CO=n2987 S=n2972 CI=n2979 B=n2980 VDD=VDD A=n2981
+ VSS=VSS
XU3403 AOI21D0BWP7T $PINS VSS=VSS A2=n2977 VDD=VDD A1=n3842 B=n3016 ZN=n2984
XU3402 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3016 A1=n4628 A3=n3842 A2=n4567
XU3401 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<185> ZN=n2977
+ A2=n4566
XU3399 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3788 ZN=n2994 A2=n4676
XU3397 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4561 ZN=n2995 A2=n3797
XU3395 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3791 ZN=n2996 A2=n4571
XU3394 INVD0BWP7T $PINS ZN=n2986 VSS=VSS VDD=VDD I=n2976
XU3393 FA1D0BWP7T $PINS CO=n2989 S=n2971 CI=n2973 B=n2974 VDD=VDD A=n2975
+ VSS=VSS
XU3392 MOAI22D0BWP7T $PINS A2=n3086 A1=n2972 ZN=SA_core_pe_3_3_N12 B1=n3084
+ VSS=VSS B2=SA_core_shift_wire<90> VDD=VDD
XU3391 INVD0BWP7T $PINS ZN=n2979 VSS=VSS VDD=VDD I=n2971
XU3390 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4567 ZN=n2973 A2=n3797
XU3388 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4628 ZN=n2974 A2=n4571
XU3387 MAOI222D1BWP7T $PINS ZN=n2980 C=n2968 B=n2969 VDD=VDD A=n2970 VSS=VSS
XU3386 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2976 A1=SA_core_output_row_3<2>
+ ZN=n2981 A2=n2967
XU3385 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4820 A1=SA_core_connect<186>
+ ZN=n2976 A3=SA_core_output_row_3<2>
XU3384 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3791 ZN=n2967 A2=n4676
XU3381 XNR3D0BWP7T $PINS A1=n4451 A2=n2970 VDD=VDD VSS=VSS A3=n2968 ZN=n2966
XU3380 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4571 ZN=n2968 A2=n3797
XU3378 INVD0BWP7T $PINS ZN=n2970 VSS=VSS VDD=VDD I=n2964
XU3376 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2975 A1=n4628 A3=n3844 A2=n4676
XU3373 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<185> ZN=n2963
+ A2=n4820
XU3372 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2961 ZN=SA_core_pe_3_3_N10
+ A2=n3084 A1=SA_core_shift_wire<88>
XU3371 OAI211D1BWP7T $PINS A2=SA_core_output_row_3<0> ZN=n2961 A1=n2960 B=n4749
+ VDD=VDD C=n2964 VSS=VSS
XU3370 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4820 A1=SA_core_connect<184>
+ ZN=n2964 A3=SA_core_output_row_3<0>
XU3369 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3797 ZN=n2960 A2=n4676
XU3366 MOAI22D0BWP7T $PINS A2=n2958 A1=n4743 ZN=SA_core_pe_0_1_N17 B1=n2590
+ VSS=VSS B2=n4533 VDD=VDD
XU3365 XNR4D0BWP7T $PINS A1=n2956 A2=n2955 ZN=n2958 A3=n2954 A4=n2953 VDD=VDD
+ VSS=VSS
XU3364 XNR4D0BWP7T $PINS A1=n2952 A2=n2951 ZN=n2953 A3=n2950 A4=n2949 VDD=VDD
+ VSS=VSS
XU3363 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<1> ZN=n2950 A2=n4817
XU3362 XOR4D0BWP7T $PINS A3=n2946 VDD=VDD A4=n2945 VSS=VSS A1=n2948 A2=n2947
+ Z=n2951
XU3361 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<6> ZN=n2945
+ A2=SA_core_connect<1>
XU3360 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<5> ZN=n2946
+ A2=SA_col_1<2>
XU3359 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<4> ZN=n2947
+ A2=SA_core_connect<3>
XU3358 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<3> ZN=n2948 A2=n4526
XU3357 FA1D0BWP7T $PINS CO=n2952 S=n2920 CI=n2942 B=n2943 VDD=VDD A=n2944
+ VSS=VSS
XU3356 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<5> ZN=n2954
+ A2=SA_core_connect<2>
XU3355 XOR4D0BWP7T $PINS A3=n2939 VDD=VDD A4=n2938 VSS=VSS A1=n2941 A2=n2937
+ Z=n2955
XU3354 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<7> ZN=n2938
+ A2=SA_core_connect<0>
XU3353 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_col_1<0> ZN=n2939
+ A2=SA_core_connect<7>
XU3351 FA1D0BWP7T $PINS CO=n2937 S=n2916 CI=n2934 B=n2935 VDD=VDD A=n2936
+ VSS=VSS
XU3350 FA1D0BWP7T $PINS CO=n2941 S=n2919 CI=n2931 B=n2932 VDD=VDD A=n2933
+ VSS=VSS
XU3349 XOR4D0BWP7T $PINS A3=n2929 VDD=VDD A4=n2928 VSS=VSS
+ A1=SA_core_shift_wire<15> A2=n2921 Z=n2956
XU3348 FA1D0BWP7T $PINS CO=n2928 S=n2931 CI=n2925 B=n2926 VDD=VDD A=n2927
+ VSS=VSS
XU3347 FA1D0BWP7T $PINS CO=n2929 S=n2933 CI=n2922 B=n2923 VDD=VDD A=n2924
+ VSS=VSS
XU3345 FA1D0BWP7T $PINS CO=n2921 S=n2935 CI=n2918 B=n2919 VDD=VDD A=n2920
+ VSS=VSS
XU3344 AO22D0BWP7T $PINS Z=SA_core_pe_0_1_N16 A2=n2916 A1=n4742 B1=n2590
+ VDD=VDD B2=n4534 VSS=VSS
XU3343 FA1D0BWP7T $PINS CO=n2934 S=n2889 CI=n2913 B=n2914 VDD=VDD A=n2915
+ VSS=VSS
XU3342 FA1D0BWP7T $PINS CO=n2918 S=n2915 CI=n2910 B=n2911 VDD=VDD A=n2912
+ VSS=VSS
XU3341 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3880 ZN=n2925 A2=n4647
XU3340 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2926 A2=SA_col_1<0> A1=n4817
XU3602 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3157 A1=n3160 ZN=n1061 A2=n3217
XU3601 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__5_ A2=SA_A_0_shift_reg_0__5_
+ ZN=n3157 A1=n4698 VDD=VDD B2=n3160 VSS=VSS
XU3600 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3156 A1=n3160 ZN=n1062 A2=n3215
XU3599 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__4_ A2=SA_A_0_shift_reg_0__4_
+ ZN=n3156 A1=n4698 VDD=VDD B2=n3160 VSS=VSS
XU3598 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3155 A1=n3160 ZN=n1063 A2=n3213
XU3597 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__3_ A2=SA_A_0_shift_reg_0__3_
+ ZN=n3155 A1=n4698 VDD=VDD B2=n3160 VSS=VSS
XU3596 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3154 A1=n3160 ZN=n1064 A2=n3211
XU3595 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__2_ A2=SA_A_0_shift_reg_0__2_
+ ZN=n3154 A1=n4698 VDD=VDD B2=n3160 VSS=VSS
XU3594 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3153 A1=n3160 ZN=n1065 A2=n3209
XU3593 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__1_ A2=SA_A_0_shift_reg_0__1_
+ ZN=n3153 A1=n4702 VDD=VDD B2=n3160 VSS=VSS
XU3592 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3152 A1=n3160 ZN=n1066 A2=n3207
XU3591 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__0_ A2=SA_A_0_shift_reg_0__0_
+ ZN=n3152 A1=n4702 VDD=VDD B2=n3160 VSS=VSS
XU3584 MAOI22D0BWP7T $PINS A2=n3222 ZN=n1067 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__7_ VSS=VSS
XU3583 MAOI22D0BWP7T $PINS A2=n3219 ZN=n1068 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__6_ VSS=VSS
XU3582 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3219 A2=n4502
XU3581 MAOI22D0BWP7T $PINS A2=n3217 ZN=n1069 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__5_ VSS=VSS
XU3580 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3217 A2=n4503
XU3579 MAOI22D0BWP7T $PINS A2=n3215 ZN=n1070 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__4_ VSS=VSS
XU3578 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3215 A2=n4504
XU3577 MAOI22D0BWP7T $PINS A2=n3213 ZN=n1071 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__3_ VSS=VSS
XU3576 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3213 A2=n4505
XU3575 MAOI22D0BWP7T $PINS A2=n3211 ZN=n1072 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__2_ VSS=VSS
XU3574 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3211 A2=n4506
XU3573 MAOI22D0BWP7T $PINS A2=n3209 ZN=n1073 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__1_ VSS=VSS
XU3572 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3209 A2=n4507
XU3571 MAOI22D0BWP7T $PINS A2=n3207 ZN=n1074 A1=n3149 B2=n3149 VDD=VDD
+ B1=SA_A_0_shift_reg_0__0_ VSS=VSS
XU3570 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3148 ZN=n3207 A2=n4508
XU3566 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3147 A1=n3202 ZN=n1075 A2=n3222
XU3565 AOI22D0BWP7T $PINS B1=n4696 A2=n3202 ZN=n3147 A1=SA_A_0_shift_reg_5__7_
+ VDD=VDD B2=SA_A_0_shift_reg_4__7_ VSS=VSS
XU3560 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3222 A2=n3148
XU3556 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n4651 ZN=n3145 A1=n4462 B2=n4654
XU3552 AOI21D0BWP7T $PINS VSS=VSS A2=n3140 VDD=VDD A1=n3141 B=n3139 ZN=n1076
XU3551 INVD0BWP7T $PINS ZN=n3141 VSS=VSS VDD=VDD
+ I=SA_ctrl_state_compute_out_counter<0>
XU3550 AOI21D0BWP7T $PINS VSS=VSS A2=n3139 VDD=VDD
+ A1=SA_ctrl_state_compute_out_counter<1> B=n3138 ZN=n1077
XU3549 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4704
+ A1=SA_ctrl_state_compute_out_counter<1> ZN=n3138 A2=n3139
XU3548 OA21D0BWP7T $PINS Z=n3139 A1=n3136 VDD=VDD A2=n4705 VSS=VSS
+ B=SA_ctrl_state_compute_out_counter<0>
XU3547 AOI21D0BWP7T $PINS VSS=VSS A2=n3133 VDD=VDD A1=n3134 B=n4708 ZN=n3136
XU3546 INVD0BWP7T $PINS ZN=n3133 VSS=VSS VDD=VDD I=n3131
XU3542 AO211D0BWP7T $PINS Z=n1080 C=n4705 B=n3125 A2=n3126 VDD=VDD
+ A1=SA_ctrl_state_load_id<1> VSS=VSS
XU3541 AOI21D0BWP7T $PINS VSS=VSS A2=n3123 VDD=VDD A1=n3124 B=n3129 ZN=n3125
XU3540 OAI211D0BWP7T $PINS A2=n4655 ZN=n3123 A1=n3122 B=n4780 VDD=VDD C=n4677
+ VSS=VSS
XU3539 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4653 ZN=n3122 A2=n4651
XU3538 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_ctrl_state_load_id<1> ZN=n3124
+ A2=n4665
XU3533 AOI31D0BWP7T $PINS B=n3117 ZN=n3118 A1=n4651 A2=n4653 VDD=VDD A3=n3128
+ VSS=VSS
XU3532 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4651 ZN=n3117 A2=n4653
XU3530 AOI21D0BWP7T $PINS VSS=VSS A2=n3144 VDD=VDD A1=n3249 B=n3119 ZN=n3116
XU3529 CKND0BWP7T $PINS ZN=n3144 VSS=VSS VDD=VDD I=SA_ctrl_state_load_AB
XU3527 OA21D0BWP7T $PINS Z=n1083 A1=n3126 VDD=VDD A2=n3115 VSS=VSS B=n3114
XU3526 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4655 A1=n3126 ZN=n3114 A2=n3113
XU3525 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n3119 A2=n3112 A1=n4772 ZN=n3115
+ C=n3129
XU3524 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3143 ZN=n3129 A2=n4509
XU3522 OAI211D0BWP7T $PINS A2=n4654 ZN=n3110 A1=SA_ctrl_state_load_id<0>
+ B=n4772 VDD=VDD C=n3113 VSS=VSS
XU3520 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3111 A1=n4650
+ A3=SA_ctrl_state_load_id<1> A2=n4653
XU3514 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n3106 A2=n3107 A1=n3108 ZN=n1084
+ C=n4705
XU3513 OA211D0BWP7T $PINS VSS=VSS C=n3108 VDD=VDD B=n4704
+ A2=SA_ctrl_state_compute_pump<2> A1=n3105 Z=n1085
XU3512 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n3105 A2=n3103 A1=n3104 ZN=n1086
+ C=n4705
XU3511 INVD0BWP7T $PINS ZN=n3103 VSS=VSS VDD=VDD
+ I=SA_ctrl_state_compute_pump<1>
XU3510 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_ctrl_state_compute_pump<0>
+ ZN=n3104 A2=n4522
XU3509 AOI21D0BWP7T $PINS VSS=VSS A2=SA_ctrl_state_compute_pump<0> VDD=VDD
+ A1=n4522 B=n3102 ZN=n1087
XU3508 AOI21D0BWP7T $PINS VSS=VSS A2=SA_ctrl_state_compute_pump<0> VDD=VDD
+ A1=n4509 B=n4699 ZN=n3102
XU3497 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3097 A1=n4522 ZN=n1089 A2=n3098
XU3496 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n4522 A1=n3098 ZN=n3097 A3=n4509
XU3490 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3107 ZN=n3106 A2=n3108
XU3489 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3105 ZN=n3108
+ A2=SA_ctrl_state_compute_pump<2>
XU3488 AN3D1BWP7T $PINS VSS=VSS A1=SA_ctrl_state_compute_pump<0> VDD=VDD
+ A2=SA_ctrl_state_compute_pump<1> A3=n4522 Z=n3105
XU3487 INVD0BWP7T $PINS ZN=n3107 VSS=VSS VDD=VDD
+ I=SA_ctrl_state_compute_pump<3>
XU3486 AOI31D1BWP7T $PINS B=n4510 ZN=n3095 A1=en A2=n4656 VDD=VDD A3=n4522
+ VSS=VSS
XU3484 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4509 ZN=n3140 A2=ack
XU3481 AOI21D0BWP7T $PINS VSS=VSS A2=n3092 VDD=VDD A1=n4769 B=n4816 ZN=n3090
XU3477 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_ctrl_state_compute_out_counter<0>
+ ZN=n3131 A2=SA_ctrl_state_compute_out_counter<1>
XU3476 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3089 ZN=n3134 A2=n3091
XU3475 MOAI22D1BWP7T $PINS A2=n3085 A1=n3086 ZN=SA_core_pe_3_3_N17
+ B1=SA_core_shift_wire<95> VSS=VSS B2=n3084 VDD=VDD
XU3474 XNR4D0BWP7T $PINS A1=n3083 A2=n3082 ZN=n3085 A3=n3081 A4=n3080 VDD=VDD
+ VSS=VSS
XU3473 XNR4D0BWP7T $PINS A1=n3079 A2=n3078 ZN=n3080 A3=n3077 A4=n3076 VDD=VDD
+ VSS=VSS
XU3472 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<185> ZN=n3077
+ A2=SA_core_connect<94>
XU3471 XOR4D0BWP7T $PINS A3=n3073 VDD=VDD A4=n3072 VSS=VSS A1=n3075 A2=n3074
+ Z=n3078
XU3470 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<190> ZN=n3072
+ A2=n4570
XU3469 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4555 ZN=n3073
+ A2=SA_core_connect<186>
XU3468 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<188> ZN=n3074
+ A2=n4560
XU3467 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<187> ZN=n3075
+ A2=SA_core_connect<92>
XU3466 FA1D0BWP7T $PINS CO=n3079 S=n3047 CI=n3069 B=n3070 VDD=VDD A=n3071
+ VSS=VSS
XU3465 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<189> ZN=n3081
+ A2=n4566
XU3464 XOR4D0BWP7T $PINS A3=n3066 VDD=VDD A4=n3065 VSS=VSS A1=n3068 A2=n3064
+ Z=n3082
XU3463 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4820 ZN=n3065
+ A2=SA_core_connect<191>
XU3462 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_core_connect<184> ZN=n3066
+ A2=SA_core_connect<95>
XU3460 FA1D0BWP7T $PINS CO=n3064 S=n3043 CI=n3061 B=n3062 VDD=VDD A=n3063
+ VSS=VSS
XU3459 FA1D0BWP7T $PINS CO=n3068 S=n3046 CI=n3058 B=n3059 VDD=VDD A=n3060
+ VSS=VSS
XU3458 XOR4D0BWP7T $PINS A3=n3056 VDD=VDD A4=n3055 VSS=VSS A1=n3048
+ A2=SA_core_output_row_3<7> Z=n3083
XU3457 FA1D0BWP7T $PINS CO=n3055 S=n3058 CI=n3052 B=n3053 VDD=VDD A=n3054
+ VSS=VSS
XU3456 FA1D0BWP7T $PINS CO=n3056 S=n3060 CI=n3049 B=n3050 VDD=VDD A=n3051
+ VSS=VSS
XU3454 FA1D0BWP7T $PINS CO=n3048 S=n3062 CI=n3045 B=n3046 VDD=VDD A=n3047
+ VSS=VSS
XU3725 MAOI22D0BWP7T $PINS A2=n3287 ZN=n1015 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__3_ VSS=VSS
XU3724 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3287 A2=n4779
XU3723 MAOI22D0BWP7T $PINS A2=n3285 ZN=n1016 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__2_ VSS=VSS
XU3722 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3285 A2=n3225
XU3721 MAOI22D0BWP7T $PINS A2=n3283 ZN=n1017 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__1_ VSS=VSS
XU3720 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3283 A2=n3225
XU3719 MAOI22D0BWP7T $PINS A2=n3281 ZN=n1018 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__0_ VSS=VSS
XU3716 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3224 A1=n3278 ZN=n1019 A2=n3296
XU3715 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__7_ A2=SA_B_3_shift_reg_4__7_
+ ZN=n3224 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3711 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3296 A2=n3225
XU3707 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3220 A1=n3222 ZN=n1020 A2=n3221
XU3706 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__7_ A2=n3221 ZN=n3220 A1=n4511
+ VDD=VDD B2=n4696 VSS=VSS
XU3705 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3218 A1=n3219 ZN=n1021 A2=n3221
XU3704 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3218 A1=n4512 VDD=VDD
+ B2=SA_A_0_shift_reg_5__6_ VSS=VSS
XU3703 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3216 A1=n3217 ZN=n1022 A2=n3221
XU3702 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3216 A1=n4514 VDD=VDD
+ B2=SA_A_0_shift_reg_5__5_ VSS=VSS
XU3701 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3214 A1=n3215 ZN=n1023 A2=n3221
XU3700 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3214 A1=n4516 VDD=VDD
+ B2=SA_A_0_shift_reg_5__4_ VSS=VSS
XU3699 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3212 A1=n3213 ZN=n1024 A2=n3221
XU3698 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3212 A1=n4518 VDD=VDD
+ B2=SA_A_0_shift_reg_5__3_ VSS=VSS
XU3697 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3210 A1=n3211 ZN=n1025 A2=n3221
XU3696 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3210 A1=SA_row_0<2> VDD=VDD
+ B2=SA_A_0_shift_reg_5__2_ VSS=VSS
XU3695 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3208 A1=n3209 ZN=n1026 A2=n3221
XU3694 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3208 A1=n4520 VDD=VDD
+ B2=SA_A_0_shift_reg_5__1_ VSS=VSS
XU3693 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3206 A1=n3207 ZN=n1027 A2=n3221
XU3692 AOI22D0BWP7T $PINS B1=n4696 A2=n3221 ZN=n3206 A1=n4639 VDD=VDD
+ B2=SA_A_0_shift_reg_5__0_ VSS=VSS
XU3689 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3201 A1=n3202 ZN=n1028 A2=n3219
XU3688 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__6_ A2=n4696 ZN=n3201
+ A1=SA_A_0_shift_reg_4__6_ VDD=VDD B2=n3202 VSS=VSS
XU3687 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3200 A1=n3202 ZN=n1029 A2=n3217
XU3686 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__5_ A2=n4696 ZN=n3200
+ A1=SA_A_0_shift_reg_4__5_ VDD=VDD B2=n3202 VSS=VSS
XU3685 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3199 A1=n3202 ZN=n1030 A2=n3215
XU3684 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__4_ A2=n4696 ZN=n3199
+ A1=SA_A_0_shift_reg_4__4_ VDD=VDD B2=n3202 VSS=VSS
XU3683 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3198 A1=n3202 ZN=n1031 A2=n3213
XU3682 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__3_ A2=n4696 ZN=n3198
+ A1=SA_A_0_shift_reg_4__3_ VDD=VDD B2=n3202 VSS=VSS
XU3681 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3197 A1=n3202 ZN=n1032 A2=n3211
XU3680 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__2_ A2=n4696 ZN=n3197
+ A1=SA_A_0_shift_reg_4__2_ VDD=VDD B2=n3202 VSS=VSS
XU3679 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3196 A1=n3202 ZN=n1033 A2=n3209
XU3678 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__1_ A2=n4696 ZN=n3196
+ A1=SA_A_0_shift_reg_4__1_ VDD=VDD B2=n3202 VSS=VSS
XU3677 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3195 A1=n3202 ZN=n1034 A2=n3207
XU3676 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_5__0_ A2=n4696 ZN=n3195
+ A1=SA_A_0_shift_reg_4__0_ VDD=VDD B2=n3202 VSS=VSS
XU3674 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3192 A1=n3222 ZN=n1035 A2=n3193
XU3673 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__7_ A2=SA_A_0_shift_reg_3__7_
+ ZN=n3192 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3672 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3191 A1=n3219 ZN=n1036 A2=n3193
XU3671 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__6_ A2=SA_A_0_shift_reg_3__6_
+ ZN=n3191 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3668 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3190 A1=n3217 ZN=n1037 A2=n3193
XU3667 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__5_ A2=SA_A_0_shift_reg_3__5_
+ ZN=n3190 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3666 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3189 A1=n3215 ZN=n1038 A2=n3193
XU3665 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__4_ A2=SA_A_0_shift_reg_3__4_
+ ZN=n3189 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3664 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3188 A1=n3213 ZN=n1039 A2=n3193
XU3663 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__3_ A2=SA_A_0_shift_reg_3__3_
+ ZN=n3188 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3662 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3187 A1=n3211 ZN=n1040 A2=n3193
XU3661 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__2_ A2=SA_A_0_shift_reg_3__2_
+ ZN=n3187 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3660 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3186 A1=n3209 ZN=n1041 A2=n3193
XU3659 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__1_ A2=SA_A_0_shift_reg_3__1_
+ ZN=n3186 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3658 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3185 A1=n3207 ZN=n1042 A2=n3193
XU3657 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_4__0_ A2=SA_A_0_shift_reg_3__0_
+ ZN=n3185 A1=n4696 VDD=VDD B2=n3193 VSS=VSS
XU3653 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3181 A1=n3222 ZN=n1043 A2=n3182
XU3652 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__7_ A2=SA_A_0_shift_reg_2__7_
+ ZN=n3181 A1=n4696 VDD=VDD B2=n3182 VSS=VSS
XU3651 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3180 A1=n3219 ZN=n1044 A2=n3182
XU3650 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__6_ A2=SA_A_0_shift_reg_2__6_
+ ZN=n3180 A1=n4702 VDD=VDD B2=n3182 VSS=VSS
XU3647 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3178 A1=n3217 ZN=n1045 A2=n3182
XU3646 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__5_ A2=SA_A_0_shift_reg_2__5_
+ ZN=n3178 A1=n4698 VDD=VDD B2=n3182 VSS=VSS
XU3645 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3177 A1=n3215 ZN=n1046 A2=n3182
XU3644 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__4_ A2=SA_A_0_shift_reg_2__4_
+ ZN=n3177 A1=n4698 VDD=VDD B2=n3182 VSS=VSS
XU3643 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3176 A1=n3213 ZN=n1047 A2=n3182
XU3642 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__3_ A2=SA_A_0_shift_reg_2__3_
+ ZN=n3176 A1=n4698 VDD=VDD B2=n3182 VSS=VSS
XU3639 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3175 A1=n3211 ZN=n1048 A2=n3182
XU3638 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__2_ A2=SA_A_0_shift_reg_2__2_
+ ZN=n3175 A1=n4698 VDD=VDD B2=n3182 VSS=VSS
XU3637 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3174 A1=n3209 ZN=n1049 A2=n3182
XU3636 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__1_ A2=SA_A_0_shift_reg_2__1_
+ ZN=n3174 A1=n4702 VDD=VDD B2=n3182 VSS=VSS
XU3635 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3173 A1=n3207 ZN=n1050 A2=n3182
XU3634 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_3__0_ A2=SA_A_0_shift_reg_2__0_
+ ZN=n3173 A1=n4696 VDD=VDD B2=n3182 VSS=VSS
XU3631 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3170 A1=n3222 ZN=n1051 A2=n3171
XU3630 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__7_ A2=SA_A_0_shift_reg_1__7_
+ ZN=n3170 A1=n4696 VDD=VDD B2=n3171 VSS=VSS
XU3629 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3169 A1=n3219 ZN=n1052 A2=n3171
XU3628 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__6_ A2=SA_A_0_shift_reg_1__6_
+ ZN=n3169 A1=n4702 VDD=VDD B2=n3171 VSS=VSS
XU3624 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3167 A1=n3217 ZN=n1053 A2=n3171
XU3623 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__5_ A2=SA_A_0_shift_reg_1__5_
+ ZN=n3167 A1=n4698 VDD=VDD B2=n3171 VSS=VSS
XU3622 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3166 A1=n3215 ZN=n1054 A2=n3171
XU3621 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__4_ A2=SA_A_0_shift_reg_1__4_
+ ZN=n3166 A1=n4698 VDD=VDD B2=n3171 VSS=VSS
XU3620 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3165 A1=n3213 ZN=n1055 A2=n3171
XU3619 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__3_ A2=SA_A_0_shift_reg_1__3_
+ ZN=n3165 A1=n4698 VDD=VDD B2=n3171 VSS=VSS
XU3618 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3164 A1=n3211 ZN=n1056 A2=n3171
XU3617 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__2_ A2=SA_A_0_shift_reg_1__2_
+ ZN=n3164 A1=n4698 VDD=VDD B2=n3171 VSS=VSS
XU3614 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3162 A1=n3209 ZN=n1057 A2=n3171
XU3613 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__1_ A2=SA_A_0_shift_reg_1__1_
+ ZN=n3162 A1=n4702 VDD=VDD B2=n3171 VSS=VSS
XU3612 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3161 A1=n3207 ZN=n1058 A2=n3171
XU3611 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_2__0_ A2=SA_A_0_shift_reg_1__0_
+ ZN=n3161 A1=n4696 VDD=VDD B2=n3171 VSS=VSS
XU3608 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3159 A1=n3222 ZN=n1059 A2=n3160
XU3607 AOI22D0BWP7T $PINS B1=SA_A_0_shift_reg_1__7_ A2=SA_A_0_shift_reg_0__7_
+ ZN=n3159 A1=n4698 VDD=VDD B2=n3160 VSS=VSS
XU3606 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3158 A1=n3160 ZN=n1060 A2=n3219
XU3605 AOI22D1BWP7T $PINS B1=SA_A_0_shift_reg_1__6_ A2=SA_A_0_shift_reg_0__6_
+ ZN=n3158 A1=n4702 VDD=VDD B2=n3160 VSS=VSS
XU3828 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3286 A1=n3287 ZN=n968 A2=n3295
XU3827 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3286 A1=SA_col_3<3> VDD=VDD
+ B2=SA_B_3_shift_reg_5__3_ VSS=VSS
XU3826 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3284 A1=n3285 ZN=n969 A2=n3295
XU3825 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3284 A1=SA_col_3<2> VDD=VDD
+ B2=SA_B_3_shift_reg_5__2_ VSS=VSS
XU3823 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3282 A1=n4641 VDD=VDD
+ B2=SA_B_3_shift_reg_5__1_ VSS=VSS
XU3821 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3280 A1=SA_col_3<0> VDD=VDD
+ B2=SA_B_3_shift_reg_5__0_ VSS=VSS
XU3819 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3277 A1=n3278 ZN=n972 A2=n3293
XU3818 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__6_ A2=SA_B_3_shift_reg_4__6_
+ ZN=n3277 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3817 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3276 A1=n3278 ZN=n973 A2=n3291
XU3816 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__5_ A2=SA_B_3_shift_reg_4__5_
+ ZN=n3276 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3815 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3275 A1=n3278 ZN=n974 A2=n3289
XU3814 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__4_ A2=SA_B_3_shift_reg_4__4_
+ ZN=n3275 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3813 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3274 A1=n3278 ZN=n975 A2=n3287
XU3812 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__3_ A2=SA_B_3_shift_reg_4__3_
+ ZN=n3274 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3811 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3273 A1=n3278 ZN=n976 A2=n3285
XU3810 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__2_ A2=SA_B_3_shift_reg_4__2_
+ ZN=n3273 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3809 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3271 A1=n3278 ZN=n977 A2=n3283
XU3808 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__1_ A2=SA_B_3_shift_reg_4__1_
+ ZN=n3271 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3806 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_5__0_ A2=SA_B_3_shift_reg_4__0_
+ ZN=n3270 A1=n4695 VDD=VDD B2=n3278 VSS=VSS
XU3805 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3268 A1=n3296 ZN=n979 A2=n3269
XU3804 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__7_ A2=SA_B_3_shift_reg_3__7_
+ ZN=n3268 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3803 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3267 A1=n3293 ZN=n980 A2=n3269
XU3802 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__6_ A2=SA_B_3_shift_reg_3__6_
+ ZN=n3267 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3801 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3266 A1=n3291 ZN=n981 A2=n3269
XU3800 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__5_ A2=SA_B_3_shift_reg_3__5_
+ ZN=n3266 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3799 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3265 A1=n3289 ZN=n982 A2=n3269
XU3798 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__4_ A2=SA_B_3_shift_reg_3__4_
+ ZN=n3265 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3797 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3264 A1=n3287 ZN=n983 A2=n3269
XU3796 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__3_ A2=SA_B_3_shift_reg_3__3_
+ ZN=n3264 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3795 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3263 A1=n3285 ZN=n984 A2=n3269
XU3794 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__2_ A2=SA_B_3_shift_reg_3__2_
+ ZN=n3263 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3793 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3262 A1=n3283 ZN=n985 A2=n3269
XU3792 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__1_ A2=SA_B_3_shift_reg_3__1_
+ ZN=n3262 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3791 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3261 A1=n3281 ZN=n986 A2=n3269
XU3790 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_4__0_ A2=SA_B_3_shift_reg_3__0_
+ ZN=n3261 A1=n4695 VDD=VDD B2=n3269 VSS=VSS
XU3788 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3259 A1=n4739 ZN=n987 A2=n3296
XU3787 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__7_ ZN=n3259 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__7_ VSS=VSS
XU3786 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3258 A1=n4739 ZN=n988 A2=n3293
XU3785 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__6_ ZN=n3258 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__6_ VSS=VSS
XU3783 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3256 A1=n4739 ZN=n989 A2=n3291
XU3782 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__5_ ZN=n3256 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__5_ VSS=VSS
XU3781 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3254 A1=n4739 ZN=n990 A2=n3289
XU3780 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__4_ ZN=n3254 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__4_ VSS=VSS
XU3779 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3253 A1=n4739 ZN=n991 A2=n3287
XU3778 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__3_ ZN=n3253 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__3_ VSS=VSS
XU3777 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3252 A1=n4739 ZN=n992 A2=n3285
XU3776 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__2_ ZN=n3252 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__2_ VSS=VSS
XU3775 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3251 A1=n4739 ZN=n993 A2=n3283
XU3774 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__1_ ZN=n3251 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__1_ VSS=VSS
XU3773 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3250 A1=n4739 ZN=n994 A2=n3281
XU3772 AOI22D0BWP7T $PINS B1=n4739 A2=SA_B_3_shift_reg_2__0_ ZN=n3250 A1=n4695
+ VDD=VDD B2=SA_B_3_shift_reg_3__0_ VSS=VSS
XU3770 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3245 A1=n3296 ZN=n995 A2=n3246
XU3769 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__7_ A2=SA_B_3_shift_reg_1__7_
+ ZN=n3245 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3768 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3244 A1=n3293 ZN=n996 A2=n3246
XU3767 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__6_ A2=SA_B_3_shift_reg_1__6_
+ ZN=n3244 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3766 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3243 A1=n3291 ZN=n997 A2=n3246
XU3765 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__5_ A2=SA_B_3_shift_reg_1__5_
+ ZN=n3243 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3764 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3242 A1=n3289 ZN=n998 A2=n3246
XU3763 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__4_ A2=SA_B_3_shift_reg_1__4_
+ ZN=n3242 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3762 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3241 A1=n3287 ZN=n999 A2=n3246
XU3761 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__3_ A2=SA_B_3_shift_reg_1__3_
+ ZN=n3241 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3760 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3240 A1=n3285 ZN=n1000 A2=n3246
XU3759 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__2_ A2=SA_B_3_shift_reg_1__2_
+ ZN=n3240 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3758 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3239 A1=n3283 ZN=n1001 A2=n3246
XU3757 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__1_ A2=SA_B_3_shift_reg_1__1_
+ ZN=n3239 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3754 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3237 A1=n3281 ZN=n1002 A2=n3246
XU3753 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_2__0_ A2=SA_B_3_shift_reg_1__0_
+ ZN=n3237 A1=n4695 VDD=VDD B2=n3246 VSS=VSS
XU3751 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3235 A1=n3296 ZN=n1003 A2=n3236
XU3750 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__7_ A2=SA_B_3_shift_reg_0__7_
+ ZN=n3235 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3747 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3234 A1=n3236 ZN=n1004 A2=n3293
XU3746 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__6_ A2=SA_B_3_shift_reg_0__6_
+ ZN=n3234 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3745 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3232 A1=n3236 ZN=n1005 A2=n3291
XU3744 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__5_ A2=SA_B_3_shift_reg_0__5_
+ ZN=n3232 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3743 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3231 A1=n3236 ZN=n1006 A2=n3289
XU3742 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__4_ A2=SA_B_3_shift_reg_0__4_
+ ZN=n3231 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3741 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3230 A1=n3236 ZN=n1007 A2=n3287
XU3740 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__3_ A2=SA_B_3_shift_reg_0__3_
+ ZN=n3230 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3739 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3229 A1=n3236 ZN=n1008 A2=n3285
XU3738 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__2_ A2=SA_B_3_shift_reg_0__2_
+ ZN=n3229 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3737 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3228 A1=n3236 ZN=n1009 A2=n3283
XU3736 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__1_ A2=SA_B_3_shift_reg_0__1_
+ ZN=n3228 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3735 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3227 A1=n3236 ZN=n1010 A2=n3281
XU3734 AOI22D0BWP7T $PINS B1=SA_B_3_shift_reg_1__0_ A2=SA_B_3_shift_reg_0__0_
+ ZN=n3227 A1=n4695 VDD=VDD B2=n3236 VSS=VSS
XU3732 MAOI22D0BWP7T $PINS A2=n3296 ZN=n1011 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__7_ VSS=VSS
XU3731 MAOI22D0BWP7T $PINS A2=n3293 ZN=n1012 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__6_ VSS=VSS
XU3730 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3293 A2=n3225
XU3729 MAOI22D0BWP7T $PINS A2=n3291 ZN=n1013 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__5_ VSS=VSS
XU3728 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3291 A2=n3225
XU3727 MAOI22D0BWP7T $PINS A2=n3289 ZN=n1014 A1=n3226 B2=n3226 VDD=VDD
+ B1=SA_B_3_shift_reg_0__4_ VSS=VSS
XU3935 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__2_ A2=SA_B_2_shift_reg_4__2_
+ ZN=n3343 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3934 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3342 A1=n3349 ZN=n921 A2=n3354
XU3933 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__1_ A2=SA_B_2_shift_reg_4__1_
+ ZN=n3342 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3932 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3341 A1=n3349 ZN=n922 A2=n3352
XU3931 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__0_ A2=SA_B_2_shift_reg_4__0_
+ ZN=n3341 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3930 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3339 A1=n3367 ZN=n923 A2=n3340
XU3929 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__7_ A2=SA_B_2_shift_reg_3__7_
+ ZN=n3339 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3928 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3338 A1=n3364 ZN=n924 A2=n3340
XU3927 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__6_ A2=SA_B_2_shift_reg_3__6_
+ ZN=n3338 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3926 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3337 A1=n3362 ZN=n925 A2=n3340
XU3925 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__5_ A2=SA_B_2_shift_reg_3__5_
+ ZN=n3337 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3924 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3336 A1=n3360 ZN=n926 A2=n3340
XU3923 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__4_ A2=SA_B_2_shift_reg_3__4_
+ ZN=n3336 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3922 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3335 A1=n3358 ZN=n927 A2=n3340
XU3921 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__3_ A2=SA_B_2_shift_reg_3__3_
+ ZN=n3335 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3920 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3334 A1=n3356 ZN=n928 A2=n3340
XU3919 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__2_ A2=SA_B_2_shift_reg_3__2_
+ ZN=n3334 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3918 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3332 A1=n3354 ZN=n929 A2=n3340
XU3917 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__1_ A2=SA_B_2_shift_reg_3__1_
+ ZN=n3332 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3916 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3331 A1=n3352 ZN=n930 A2=n3340
XU3915 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_4__0_ A2=SA_B_2_shift_reg_3__0_
+ ZN=n3331 A1=n4699 VDD=VDD B2=n3340 VSS=VSS
XU3913 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3329 A1=n3367 ZN=n931 A2=n3330
XU3912 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__7_ A2=SA_B_2_shift_reg_2__7_
+ ZN=n3329 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3911 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3328 A1=n3364 ZN=n932 A2=n3330
XU3910 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__6_ A2=SA_B_2_shift_reg_2__6_
+ ZN=n3328 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3909 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3327 A1=n3362 ZN=n933 A2=n3330
XU3908 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__5_ A2=SA_B_2_shift_reg_2__5_
+ ZN=n3327 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3907 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3326 A1=n3360 ZN=n934 A2=n3330
XU3906 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__4_ A2=SA_B_2_shift_reg_2__4_
+ ZN=n3326 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3905 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3325 A1=n3358 ZN=n935 A2=n3330
XU3904 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__3_ A2=SA_B_2_shift_reg_2__3_
+ ZN=n3325 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3903 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3324 A1=n3356 ZN=n936 A2=n3330
XU3902 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__2_ A2=SA_B_2_shift_reg_2__2_
+ ZN=n3324 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3901 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3323 A1=n3354 ZN=n937 A2=n3330
XU3900 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__1_ A2=SA_B_2_shift_reg_2__1_
+ ZN=n3323 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3899 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3322 A1=n3352 ZN=n938 A2=n3330
XU3898 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_3__0_ A2=SA_B_2_shift_reg_2__0_
+ ZN=n3322 A1=n4699 VDD=VDD B2=n3330 VSS=VSS
XU3896 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3320 A1=n3367 ZN=n939 A2=n3321
XU3895 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__7_ A2=SA_B_2_shift_reg_1__7_
+ ZN=n3320 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3894 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3319 A1=n3364 ZN=n940 A2=n3321
XU3893 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__6_ A2=SA_B_2_shift_reg_1__6_
+ ZN=n3319 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3891 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3317 A1=n3362 ZN=n941 A2=n3321
XU3890 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__5_ A2=SA_B_2_shift_reg_1__5_
+ ZN=n3317 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3889 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3315 A1=n3360 ZN=n942 A2=n3321
XU3888 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__4_ A2=SA_B_2_shift_reg_1__4_
+ ZN=n3315 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3887 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3314 A1=n3358 ZN=n943 A2=n3321
XU3886 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__3_ A2=SA_B_2_shift_reg_1__3_
+ ZN=n3314 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3885 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3313 A1=n3356 ZN=n944 A2=n3321
XU3884 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__2_ A2=SA_B_2_shift_reg_1__2_
+ ZN=n3313 A1=n4699 VDD=VDD B2=n3321 VSS=VSS
XU3883 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3312 A1=n3354 ZN=n945 A2=n3321
XU3882 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__1_ A2=SA_B_2_shift_reg_1__1_
+ ZN=n3312 A1=n4696 VDD=VDD B2=n3321 VSS=VSS
XU3881 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3311 A1=n3352 ZN=n946 A2=n3321
XU3880 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_2__0_ A2=SA_B_2_shift_reg_1__0_
+ ZN=n3311 A1=n4696 VDD=VDD B2=n3321 VSS=VSS
XU3878 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3309 A1=n3367 ZN=n947 A2=n3310
XU3877 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__7_ A2=SA_B_2_shift_reg_0__7_
+ ZN=n3309 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3876 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3308 A1=n3310 ZN=n948 A2=n3364
XU3875 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__6_ A2=SA_B_2_shift_reg_0__6_
+ ZN=n3308 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3874 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3307 A1=n3310 ZN=n949 A2=n3362
XU3873 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__5_ A2=SA_B_2_shift_reg_0__5_
+ ZN=n3307 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3872 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3306 A1=n3310 ZN=n950 A2=n3360
XU3871 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__4_ A2=SA_B_2_shift_reg_0__4_
+ ZN=n3306 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3870 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3305 A1=n3310 ZN=n951 A2=n3358
XU3869 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__3_ A2=SA_B_2_shift_reg_0__3_
+ ZN=n3305 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3868 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3304 A1=n3310 ZN=n952 A2=n3356
XU3867 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__2_ A2=SA_B_2_shift_reg_0__2_
+ ZN=n3304 A1=n4699 VDD=VDD B2=n3310 VSS=VSS
XU3866 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n3303 A1=n3310 ZN=n953 A2=n3354
XU3865 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__1_ A2=SA_B_2_shift_reg_0__1_
+ ZN=n3303 A1=n4696 VDD=VDD B2=n3310 VSS=VSS
XU3863 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3301 A1=n3310 ZN=n954 A2=n3352
XU3862 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_1__0_ A2=SA_B_2_shift_reg_0__0_
+ ZN=n3301 A1=n4696 VDD=VDD B2=n3310 VSS=VSS
XU3860 MAOI22D0BWP7T $PINS A2=n3367 ZN=n955 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__7_ VSS=VSS
XU3859 MAOI22D0BWP7T $PINS A2=n3364 ZN=n956 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__6_ VSS=VSS
XU3858 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3364 A2=n4765
XU3857 MAOI22D0BWP7T $PINS A2=n3362 ZN=n957 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__5_ VSS=VSS
XU3856 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3362 A2=n4765
XU3855 MAOI22D0BWP7T $PINS A2=n3360 ZN=n958 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__4_ VSS=VSS
XU3854 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3360 A2=n4765
XU3853 MAOI22D0BWP7T $PINS A2=n3358 ZN=n959 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__3_ VSS=VSS
XU3852 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3358 A2=n4765
XU3851 MAOI22D0BWP7T $PINS A2=n3356 ZN=n960 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__2_ VSS=VSS
XU3850 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3356 A2=n4765
XU3849 MAOI22D0BWP7T $PINS A2=n3354 ZN=n961 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__1_ VSS=VSS
XU3848 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3354 A2=n4765
XU3847 MAOI22D0BWP7T $PINS A2=n3352 ZN=n962 A1=n3299 B2=n3299 VDD=VDD
+ B1=SA_B_2_shift_reg_0__0_ VSS=VSS
XU3846 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3352 A2=n4765
XU3844 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3297 A1=n3349 ZN=n963 A2=n3367
XU3843 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__7_ A2=SA_B_2_shift_reg_4__7_
+ ZN=n3297 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3842 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3367 A2=n4765
XU3838 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3294 A1=n3296 ZN=n964 A2=n3295
XU3837 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3294 A1=SA_col_3<7> VDD=VDD
+ B2=SA_B_3_shift_reg_5__7_ VSS=VSS
XU3834 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3292 A1=n3293 ZN=n965 A2=n3295
XU3832 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3290 A1=n3291 ZN=n966 A2=n3295
XU3831 AOI22D0BWP7T $PINS B1=n4695 A2=n3295 ZN=n3290 A1=SA_col_3<5> VDD=VDD
+ B2=SA_B_3_shift_reg_5__5_ VSS=VSS
XU4042 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__1_ A2=SA_B_1_shift_reg_3__1_
+ ZN=n3404 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4041 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3402 A1=n3423 ZN=n874 A2=n3411
XU4040 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__0_ A2=SA_B_1_shift_reg_3__0_
+ ZN=n3402 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4037 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3399 A1=n3441 ZN=n875 A2=n3400
XU4036 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__7_ A2=SA_B_1_shift_reg_2__7_
+ ZN=n3399 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4035 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3398 A1=n3437 ZN=n876 A2=n3400
XU4034 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__6_ A2=SA_B_1_shift_reg_2__6_
+ ZN=n3398 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4033 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3397 A1=n3435 ZN=n877 A2=n3400
XU4032 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__5_ A2=SA_B_1_shift_reg_2__5_
+ ZN=n3397 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4031 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3396 A1=n3433 ZN=n878 A2=n3400
XU4030 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__4_ A2=SA_B_1_shift_reg_2__4_
+ ZN=n3396 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4029 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3395 A1=n3431 ZN=n879 A2=n3400
XU4028 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__3_ A2=SA_B_1_shift_reg_2__3_
+ ZN=n3395 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4027 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3394 A1=n3428 ZN=n880 A2=n3400
XU4026 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__2_ A2=SA_B_1_shift_reg_2__2_
+ ZN=n3394 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4025 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3393 A1=n3425 ZN=n881 A2=n3400
XU4024 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__1_ A2=SA_B_1_shift_reg_2__1_
+ ZN=n3393 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4023 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3392 A1=n3423 ZN=n882 A2=n3400
XU4022 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_3__0_ A2=SA_B_1_shift_reg_2__0_
+ ZN=n3392 A1=n4700 VDD=VDD B2=n3400 VSS=VSS
XU4020 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3390 A1=n3441 ZN=n883 A2=n3391
XU4019 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__7_ A2=SA_B_1_shift_reg_1__7_
+ ZN=n3390 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4018 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3389 A1=n3437 ZN=n884 A2=n3391
XU4017 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__6_ A2=SA_B_1_shift_reg_1__6_
+ ZN=n3389 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4016 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3388 A1=n3435 ZN=n885 A2=n3391
XU4015 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__5_ A2=SA_B_1_shift_reg_1__5_
+ ZN=n3388 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4014 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3387 A1=n3433 ZN=n886 A2=n3391
XU4013 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__4_ A2=SA_B_1_shift_reg_1__4_
+ ZN=n3387 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4011 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3385 A1=n3431 ZN=n887 A2=n3391
XU4010 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__3_ A2=SA_B_1_shift_reg_1__3_
+ ZN=n3385 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4009 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3383 A1=n3428 ZN=n888 A2=n3391
XU4008 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__2_ A2=SA_B_1_shift_reg_1__2_
+ ZN=n3383 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4007 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3382 A1=n3425 ZN=n889 A2=n3391
XU4006 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__1_ A2=SA_B_1_shift_reg_1__1_
+ ZN=n3382 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4005 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3381 A1=n3423 ZN=n890 A2=n3391
XU4004 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_2__0_ A2=SA_B_1_shift_reg_1__0_
+ ZN=n3381 A1=n4700 VDD=VDD B2=n3391 VSS=VSS
XU4002 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3379 A1=n3441 ZN=n891 A2=n3380
XU4001 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__7_ A2=SA_B_1_shift_reg_0__7_
+ ZN=n3379 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU4000 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3378 A1=n3380 ZN=n892 A2=n3437
XU3999 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__6_ A2=SA_B_1_shift_reg_0__6_
+ ZN=n3378 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3998 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3377 A1=n3380 ZN=n893 A2=n3435
XU3997 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__5_ A2=SA_B_1_shift_reg_0__5_
+ ZN=n3377 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3996 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3376 A1=n3380 ZN=n894 A2=n3433
XU3995 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__4_ A2=SA_B_1_shift_reg_0__4_
+ ZN=n3376 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3994 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3375 A1=n3380 ZN=n895 A2=n3431
XU3993 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__3_ A2=SA_B_1_shift_reg_0__3_
+ ZN=n3375 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3992 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3374 A1=n3380 ZN=n896 A2=n3428
XU3991 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__2_ A2=SA_B_1_shift_reg_0__2_
+ ZN=n3374 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3990 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3373 A1=n3380 ZN=n897 A2=n3425
XU3989 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__1_ A2=SA_B_1_shift_reg_0__1_
+ ZN=n3373 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3988 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3372 A1=n3380 ZN=n898 A2=n3423
XU3987 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_1__0_ A2=SA_B_1_shift_reg_0__0_
+ ZN=n3372 A1=n4700 VDD=VDD B2=n3380 VSS=VSS
XU3985 MAOI22D0BWP7T $PINS A2=n3441 ZN=n899 A1=n3371 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__7_ VSS=VSS
XU3984 MAOI22D0BWP7T $PINS A2=n3437 ZN=n900 A1=n3371 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__6_ VSS=VSS
XU3983 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3437 A2=n3370
XU3982 MAOI22D0BWP7T $PINS A2=n3435 ZN=n901 A1=n3371 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__5_ VSS=VSS
XU3981 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3435 A2=n4766
XU3980 MAOI22D0BWP7T $PINS A2=n3433 ZN=n902 A1=n4800 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__4_ VSS=VSS
XU3979 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3433 A2=n3370
XU3978 MAOI22D0BWP7T $PINS A2=n3431 ZN=n903 A1=n4800 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__3_ VSS=VSS
XU3977 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3431 A2=n4766
XU3976 MAOI22D0BWP7T $PINS A2=n3428 ZN=n904 A1=n4800 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__2_ VSS=VSS
XU3975 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3428 A2=n4766
XU3974 MAOI22D0BWP7T $PINS A2=n3425 ZN=n905 A1=n4800 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__1_ VSS=VSS
XU3973 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3425 A2=n4766
XU3972 MAOI22D0BWP7T $PINS A2=n3423 ZN=n906 A1=n4800 B2=n3371 VDD=VDD
+ B1=SA_B_1_shift_reg_0__0_ VSS=VSS
XU3971 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3423 A2=n4766
XU3969 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3369 A1=n3420 ZN=n907 A2=n3441
XU3968 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__7_ A2=SA_B_1_shift_reg_4__7_
+ ZN=n3369 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU3965 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3441 A2=n3370
XU3960 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3365 A1=SA_col_2<7> VDD=VDD
+ B2=SA_B_2_shift_reg_5__7_ VSS=VSS
XU3959 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3363 A1=n3364 ZN=n909 A2=n3366
XU3958 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3363 A1=SA_col_2<6> VDD=VDD
+ B2=SA_B_2_shift_reg_5__6_ VSS=VSS
XU3957 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3361 A1=n3362 ZN=n910 A2=n3366
XU3956 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3361 A1=n4658 VDD=VDD
+ B2=SA_B_2_shift_reg_5__5_ VSS=VSS
XU3955 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3359 A1=n3360 ZN=n911 A2=n3366
XU3954 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3359 A1=n4660 VDD=VDD
+ B2=SA_B_2_shift_reg_5__4_ VSS=VSS
XU3953 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3357 A1=n3358 ZN=n912 A2=n3366
XU3952 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3357 A1=SA_col_2<3> VDD=VDD
+ B2=SA_B_2_shift_reg_5__3_ VSS=VSS
XU3951 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3355 A1=n3356 ZN=n913 A2=n3366
XU3950 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3355 A1=n4672 VDD=VDD
+ B2=SA_B_2_shift_reg_5__2_ VSS=VSS
XU3949 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3353 A1=n3354 ZN=n914 A2=n3366
XU3948 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3353 A1=SA_col_2<1> VDD=VDD
+ B2=SA_B_2_shift_reg_5__1_ VSS=VSS
XU3947 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3351 A1=n3352 ZN=n915 A2=n3366
XU3946 AOI22D0BWP7T $PINS B1=n4699 A2=n3366 ZN=n3351 A1=n4682 VDD=VDD
+ B2=SA_B_2_shift_reg_5__0_ VSS=VSS
XU3944 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3348 A1=n3349 ZN=n916 A2=n3364
XU3943 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__6_ A2=SA_B_2_shift_reg_4__6_
+ ZN=n3348 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3942 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3346 A1=n3349 ZN=n917 A2=n3362
XU3941 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__5_ A2=SA_B_2_shift_reg_4__5_
+ ZN=n3346 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3940 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3345 A1=n3349 ZN=n918 A2=n3360
XU3939 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__4_ A2=SA_B_2_shift_reg_4__4_
+ ZN=n3345 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3938 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3344 A1=n3349 ZN=n919 A2=n3358
XU3937 AOI22D0BWP7T $PINS B1=SA_B_2_shift_reg_5__3_ A2=SA_B_2_shift_reg_4__3_
+ ZN=n3344 A1=n4699 VDD=VDD B2=n3349 VSS=VSS
XU3936 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3343 A1=n3349 ZN=n920 A2=n3356
XU4144 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3464 A1=n3513 ZN=n827 A2=n3465
XU4143 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__7_ A2=SA_B_0_shift_reg_1__7_
+ ZN=n3464 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4142 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3463 A1=n3509 ZN=n828 A2=n3465
XU4141 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__6_ A2=SA_B_0_shift_reg_1__6_
+ ZN=n3463 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4140 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3462 A1=n3507 ZN=n829 A2=n3465
XU4139 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__5_ A2=SA_B_0_shift_reg_1__5_
+ ZN=n3462 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4138 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3461 A1=n3505 ZN=n830 A2=n3465
XU4137 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__4_ A2=SA_B_0_shift_reg_1__4_
+ ZN=n3461 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4136 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3460 A1=n3503 ZN=n831 A2=n3465
XU4135 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__3_ A2=SA_B_0_shift_reg_1__3_
+ ZN=n3460 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4134 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3459 A1=n3501 ZN=n832 A2=n3465
XU4133 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__2_ A2=SA_B_0_shift_reg_1__2_
+ ZN=n3459 A1=n4696 VDD=VDD B2=n3465 VSS=VSS
XU4132 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3458 A1=n3499 ZN=n833 A2=n3465
XU4131 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__1_ A2=SA_B_0_shift_reg_1__1_
+ ZN=n3458 A1=n4698 VDD=VDD B2=n3465 VSS=VSS
XU4130 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3456 A1=n3497 ZN=n834 A2=n3465
XU4129 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_2__0_ A2=SA_B_0_shift_reg_1__0_
+ ZN=n3456 A1=n4696 VDD=VDD B2=n3465 VSS=VSS
XU4126 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3453 A1=n3513 ZN=n835 A2=n3454
XU4125 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__7_ A2=SA_B_0_shift_reg_0__7_
+ ZN=n3453 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4124 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3452 A1=n3454 ZN=n836 A2=n3509
XU4123 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__6_ A2=SA_B_0_shift_reg_0__6_
+ ZN=n3452 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4122 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3451 A1=n3454 ZN=n837 A2=n3507
XU4121 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__5_ A2=SA_B_0_shift_reg_0__5_
+ ZN=n3451 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4120 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3450 A1=n3454 ZN=n838 A2=n3505
XU4119 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__4_ A2=SA_B_0_shift_reg_0__4_
+ ZN=n3450 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4118 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3449 A1=n3454 ZN=n839 A2=n3503
XU4117 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__3_ A2=SA_B_0_shift_reg_0__3_
+ ZN=n3449 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4116 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3448 A1=n3454 ZN=n840 A2=n3501
XU4115 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__2_ A2=SA_B_0_shift_reg_0__2_
+ ZN=n3448 A1=n4696 VDD=VDD B2=n3454 VSS=VSS
XU4114 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3447 A1=n3454 ZN=n841 A2=n3499
XU4113 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__1_ A2=SA_B_0_shift_reg_0__1_
+ ZN=n3447 A1=n4698 VDD=VDD B2=n3454 VSS=VSS
XU4112 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3446 A1=n3454 ZN=n842 A2=n3497
XU4111 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_1__0_ A2=SA_B_0_shift_reg_0__0_
+ ZN=n3446 A1=n4696 VDD=VDD B2=n3454 VSS=VSS
XU4109 MAOI22D0BWP7T $PINS A2=n3513 ZN=n843 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__7_ VSS=VSS
XU4108 MAOI22D0BWP7T $PINS A2=n3509 ZN=n844 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__6_ VSS=VSS
XU4107 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3509 A2=n3444
XU4106 MAOI22D0BWP7T $PINS A2=n3507 ZN=n845 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__5_ VSS=VSS
XU4105 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3507 A2=n3444
XU4104 MAOI22D0BWP7T $PINS A2=n3505 ZN=n846 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__4_ VSS=VSS
XU4103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3505 A2=n3444
XU4102 MAOI22D0BWP7T $PINS A2=n3503 ZN=n847 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__3_ VSS=VSS
XU4101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3503 A2=n3444
XU4100 MAOI22D0BWP7T $PINS A2=n3501 ZN=n848 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__2_ VSS=VSS
XU4099 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3501 A2=n3444
XU4098 MAOI22D0BWP7T $PINS A2=n3499 ZN=n849 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__1_ VSS=VSS
XU4097 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3499 A2=n3444
XU4096 MAOI22D0BWP7T $PINS A2=n3497 ZN=n850 A1=n3445 B2=n3445 VDD=VDD
+ B1=SA_B_0_shift_reg_0__0_ VSS=VSS
XU4095 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3497 A2=n3444
XU4093 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3443 A1=n3494 ZN=n851 A2=n3513
XU4092 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__7_ A2=SA_B_0_shift_reg_4__7_
+ ZN=n3443 A1=n4698 VDD=VDD B2=n3494 VSS=VSS
XU4091 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3513 A2=n3444
XU4087 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3439 A1=n3441 ZN=n852 A2=n3440
XU4086 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3439 A1=SA_col_1<7> VDD=VDD
+ B2=SA_B_1_shift_reg_5__7_ VSS=VSS
XU4085 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3436 A1=n3437 ZN=n853 A2=n3440
XU4084 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3436 A1=SA_col_1<6> VDD=VDD
+ B2=SA_B_1_shift_reg_5__6_ VSS=VSS
XU4083 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3434 A1=n3435 ZN=n854 A2=n3440
XU4082 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3434 A1=SA_col_1<5> VDD=VDD
+ B2=SA_B_1_shift_reg_5__5_ VSS=VSS
XU4081 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3432 A1=n3433 ZN=n855 A2=n3440
XU4080 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3432 A1=SA_col_1<4> VDD=VDD
+ B2=SA_B_1_shift_reg_5__4_ VSS=VSS
XU4079 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3430 A1=n3431 ZN=n856 A2=n3440
XU4078 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3430 A1=SA_col_1<3> VDD=VDD
+ B2=SA_B_1_shift_reg_5__3_ VSS=VSS
XU4076 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3427 A1=n3428 ZN=n857 A2=n3440
XU4075 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3427 A1=SA_col_1<2> VDD=VDD
+ B2=SA_B_1_shift_reg_5__2_ VSS=VSS
XU4074 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3424 A1=n3425 ZN=n858 A2=n3440
XU4073 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3424 A1=SA_col_1<1> VDD=VDD
+ B2=SA_B_1_shift_reg_5__1_ VSS=VSS
XU4072 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3422 A1=n3423 ZN=n859 A2=n3440
XU4071 AOI22D0BWP7T $PINS B1=n4700 A2=n3440 ZN=n3422 A1=SA_col_1<0> VDD=VDD
+ B2=SA_B_1_shift_reg_5__0_ VSS=VSS
XU4069 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3419 A1=n3420 ZN=n860 A2=n3437
XU4068 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__6_ A2=SA_B_1_shift_reg_4__6_
+ ZN=n3419 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4067 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3418 A1=n3420 ZN=n861 A2=n3435
XU4066 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__5_ A2=SA_B_1_shift_reg_4__5_
+ ZN=n3418 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4065 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3416 A1=n3420 ZN=n862 A2=n3433
XU4064 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__4_ A2=SA_B_1_shift_reg_4__4_
+ ZN=n3416 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4063 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3415 A1=n3420 ZN=n863 A2=n3431
XU4062 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__3_ A2=SA_B_1_shift_reg_4__3_
+ ZN=n3415 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4061 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3414 A1=n3420 ZN=n864 A2=n3428
XU4060 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__2_ A2=SA_B_1_shift_reg_4__2_
+ ZN=n3414 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4059 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3413 A1=n3420 ZN=n865 A2=n3425
XU4058 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__1_ A2=SA_B_1_shift_reg_4__1_
+ ZN=n3413 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4057 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3412 A1=n3420 ZN=n866 A2=n3423
XU4056 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_5__0_ A2=SA_B_1_shift_reg_4__0_
+ ZN=n3412 A1=n4700 VDD=VDD B2=n3420 VSS=VSS
XU4055 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3410 A1=n3441 ZN=n867 A2=n3411
XU4054 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__7_ A2=SA_B_1_shift_reg_3__7_
+ ZN=n3410 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4053 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3409 A1=n3437 ZN=n868 A2=n3411
XU4052 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__6_ A2=SA_B_1_shift_reg_3__6_
+ ZN=n3409 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4051 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3408 A1=n3435 ZN=n869 A2=n3411
XU4050 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__5_ A2=SA_B_1_shift_reg_3__5_
+ ZN=n3408 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4049 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3407 A1=n3433 ZN=n870 A2=n3411
XU4048 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__4_ A2=SA_B_1_shift_reg_3__4_
+ ZN=n3407 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4047 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3406 A1=n3431 ZN=n871 A2=n3411
XU4046 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__3_ A2=SA_B_1_shift_reg_3__3_
+ ZN=n3406 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4045 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3405 A1=n3428 ZN=n872 A2=n3411
XU4044 AOI22D0BWP7T $PINS B1=SA_B_1_shift_reg_4__2_ A2=SA_B_1_shift_reg_3__2_
+ ZN=n3405 A1=n4700 VDD=VDD B2=n3411 VSS=VSS
XU4043 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3404 A1=n3425 ZN=n873 A2=n3411
XU4249 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__6_ A2=SA_A_3_shift_reg_0__6_
+ ZN=n3526 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4248 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3525 A1=n3528 ZN=n781 A2=n3579
XU4247 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__5_ A2=SA_A_3_shift_reg_0__5_
+ ZN=n3525 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4246 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3524 A1=n3528 ZN=n782 A2=n3577
XU4245 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__4_ A2=SA_A_3_shift_reg_0__4_
+ ZN=n3524 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4244 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3522 A1=n3528 ZN=n783 A2=n3575
XU4243 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__3_ A2=SA_A_3_shift_reg_0__3_
+ ZN=n3522 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4242 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3521 A1=n3528 ZN=n784 A2=n3573
XU4241 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__2_ A2=SA_A_3_shift_reg_0__2_
+ ZN=n3521 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4239 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3519 A1=n3528 ZN=n785 A2=n3571
XU4238 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__1_ A2=SA_A_3_shift_reg_0__1_
+ ZN=n3519 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4237 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3518 A1=n3528 ZN=n786 A2=n3569
XU4236 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__0_ A2=SA_A_3_shift_reg_0__0_
+ ZN=n3518 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4234 MAOI22D0BWP7T $PINS A2=n3584 ZN=n787 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__7_ VSS=VSS
XU4233 MAOI22D0BWP7T $PINS A2=n3581 ZN=n788 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__6_ VSS=VSS
XU4232 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3581 A2=n3516
XU4231 MAOI22D0BWP7T $PINS A2=n3579 ZN=n789 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__5_ VSS=VSS
XU4230 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3579 A2=n3516
XU4229 MAOI22D0BWP7T $PINS A2=n3577 ZN=n790 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__4_ VSS=VSS
XU4227 MAOI22D0BWP7T $PINS A2=n3575 ZN=n791 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__3_ VSS=VSS
XU4225 MAOI22D0BWP7T $PINS A2=n3573 ZN=n792 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__2_ VSS=VSS
XU4224 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3573 A2=n3516
XU4223 MAOI22D0BWP7T $PINS A2=n3571 ZN=n793 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__1_ VSS=VSS
XU4222 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3571 A2=n3516
XU4221 MAOI22D0BWP7T $PINS A2=n3569 ZN=n794 A1=n3517 B2=n3517 VDD=VDD
+ B1=SA_A_3_shift_reg_0__0_ VSS=VSS
XU4220 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3569 A2=n3516
XU4218 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3515 A1=n3566 ZN=n795 A2=n3584
XU4217 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__7_ A2=SA_A_3_shift_reg_4__7_
+ ZN=n3515 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4216 CKND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3584 A2=n3516
XU4212 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3511 A1=n3513 ZN=n796 A2=n3512
XU4211 AOI22D0BWP7T $PINS B1=n4698 A2=n3512 ZN=n3511 A1=n4652 VDD=VDD
+ B2=SA_B_0_shift_reg_5__7_ VSS=VSS
XU4208 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3508 A1=n3509 ZN=n797 A2=n3512
XU4207 AOI22D0BWP7T $PINS B1=n4698 A2=n3512 ZN=n3508 A1=SA_col_0<6> VDD=VDD
+ B2=SA_B_0_shift_reg_5__6_ VSS=VSS
XU4206 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3506 A1=n3507 ZN=n798 A2=n3512
XU4205 AOI22D0BWP7T $PINS B1=n4698 A2=n3512 ZN=n3506 A1=SA_col_0<5> VDD=VDD
+ B2=SA_B_0_shift_reg_5__5_ VSS=VSS
XU4204 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3504 A1=n3505 ZN=n799 A2=n3512
XU4203 AOI22D0BWP7T $PINS B1=n4698 A2=n3512 ZN=n3504 A1=SA_col_0<4> VDD=VDD
+ B2=SA_B_0_shift_reg_5__4_ VSS=VSS
XU4202 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3502 A1=n3503 ZN=n800 A2=n3512
XU4201 AOI22D0BWP7T $PINS B1=n4698 A2=n3512 ZN=n3502 A1=SA_col_0<3> VDD=VDD
+ B2=SA_B_0_shift_reg_5__3_ VSS=VSS
XU4200 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3500 A1=n3501 ZN=n801 A2=n3512
XU4199 AOI22D0BWP7T $PINS B1=n4696 A2=n3512 ZN=n3500 A1=n4674 VDD=VDD
+ B2=SA_B_0_shift_reg_5__2_ VSS=VSS
XU4198 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3498 A1=n3499 ZN=n802 A2=n3512
XU4197 AOI22D0BWP7T $PINS B1=n4696 A2=n3512 ZN=n3498 A1=SA_col_0<1> VDD=VDD
+ B2=SA_B_0_shift_reg_5__1_ VSS=VSS
XU4196 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3496 A1=n3497 ZN=n803 A2=n3512
XU4195 AOI22D0BWP7T $PINS B1=n4696 A2=n3512 ZN=n3496 A1=SA_col_0<0> VDD=VDD
+ B2=SA_B_0_shift_reg_5__0_ VSS=VSS
XU4193 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3493 A1=n3494 ZN=n804 A2=n3509
XU4192 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__6_ A2=SA_B_0_shift_reg_4__6_
+ ZN=n3493 A1=n4698 VDD=VDD B2=n3494 VSS=VSS
XU4191 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3492 A1=n3494 ZN=n805 A2=n3507
XU4190 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__5_ A2=SA_B_0_shift_reg_4__5_
+ ZN=n3492 A1=n4698 VDD=VDD B2=n3494 VSS=VSS
XU4189 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3491 A1=n3494 ZN=n806 A2=n3505
XU4188 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__4_ A2=SA_B_0_shift_reg_4__4_
+ ZN=n3491 A1=n4698 VDD=VDD B2=n3494 VSS=VSS
XU4187 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3490 A1=n3494 ZN=n807 A2=n3503
XU4186 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__3_ A2=SA_B_0_shift_reg_4__3_
+ ZN=n3490 A1=n4698 VDD=VDD B2=n3494 VSS=VSS
XU4185 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3489 A1=n3494 ZN=n808 A2=n3501
XU4184 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__2_ A2=SA_B_0_shift_reg_4__2_
+ ZN=n3489 A1=n4696 VDD=VDD B2=n3494 VSS=VSS
XU4182 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3487 A1=n3494 ZN=n809 A2=n3499
XU4181 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__1_ A2=SA_B_0_shift_reg_4__1_
+ ZN=n3487 A1=n4696 VDD=VDD B2=n3494 VSS=VSS
XU4180 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3485 A1=n3494 ZN=n810 A2=n3497
XU4179 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_5__0_ A2=SA_B_0_shift_reg_4__0_
+ ZN=n3485 A1=n4696 VDD=VDD B2=n3494 VSS=VSS
XU4178 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3483 A1=n3513 ZN=n811 A2=n3484
XU4177 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__7_ A2=SA_B_0_shift_reg_3__7_
+ ZN=n3483 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4176 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3482 A1=n3509 ZN=n812 A2=n3484
XU4175 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__6_ A2=SA_B_0_shift_reg_3__6_
+ ZN=n3482 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4174 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3481 A1=n3507 ZN=n813 A2=n3484
XU4173 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__5_ A2=SA_B_0_shift_reg_3__5_
+ ZN=n3481 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4172 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3480 A1=n3505 ZN=n814 A2=n3484
XU4171 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__4_ A2=SA_B_0_shift_reg_3__4_
+ ZN=n3480 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4170 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3479 A1=n3503 ZN=n815 A2=n3484
XU4169 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__3_ A2=SA_B_0_shift_reg_3__3_
+ ZN=n3479 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4168 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3478 A1=n3501 ZN=n816 A2=n3484
XU4167 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__2_ A2=SA_B_0_shift_reg_3__2_
+ ZN=n3478 A1=n4696 VDD=VDD B2=n3484 VSS=VSS
XU4166 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3477 A1=n3499 ZN=n817 A2=n3484
XU4165 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__1_ A2=SA_B_0_shift_reg_3__1_
+ ZN=n3477 A1=n4698 VDD=VDD B2=n3484 VSS=VSS
XU4164 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3476 A1=n3497 ZN=n818 A2=n3484
XU4163 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_4__0_ A2=SA_B_0_shift_reg_3__0_
+ ZN=n3476 A1=n4696 VDD=VDD B2=n3484 VSS=VSS
XU4161 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3474 A1=n3513 ZN=n819 A2=n3475
XU4160 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__7_ A2=SA_B_0_shift_reg_2__7_
+ ZN=n3474 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4159 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3473 A1=n3509 ZN=n820 A2=n3475
XU4158 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__6_ A2=SA_B_0_shift_reg_2__6_
+ ZN=n3473 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4157 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3472 A1=n3507 ZN=n821 A2=n3475
XU4156 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__5_ A2=SA_B_0_shift_reg_2__5_
+ ZN=n3472 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4155 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3470 A1=n3505 ZN=n822 A2=n3475
XU4154 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__4_ A2=SA_B_0_shift_reg_2__4_
+ ZN=n3470 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4153 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3469 A1=n3503 ZN=n823 A2=n3475
XU4152 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__3_ A2=SA_B_0_shift_reg_2__3_
+ ZN=n3469 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4151 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3468 A1=n3501 ZN=n824 A2=n3475
XU4150 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__2_ A2=SA_B_0_shift_reg_2__2_
+ ZN=n3468 A1=n4696 VDD=VDD B2=n3475 VSS=VSS
XU4149 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3467 A1=n3499 ZN=n825 A2=n3475
XU4148 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__1_ A2=SA_B_0_shift_reg_2__1_
+ ZN=n3467 A1=n4698 VDD=VDD B2=n3475 VSS=VSS
XU4147 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3466 A1=n3497 ZN=n826 A2=n3475
XU4146 AOI22D0BWP7T $PINS B1=SA_B_0_shift_reg_3__0_ A2=SA_B_0_shift_reg_2__0_
+ ZN=n3466 A1=n4696 VDD=VDD B2=n3475 VSS=VSS
XU4351 MAOI22D0BWP7T $PINS A2=n3650 ZN=n734 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__4_ VSS=VSS
XU4350 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3650 A2=n4723
XU4349 MAOI22D0BWP7T $PINS A2=n3648 ZN=n735 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__3_ VSS=VSS
XU4347 MAOI22D0BWP7T $PINS A2=n3645 ZN=n736 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__2_ VSS=VSS
XU4346 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3645 A2=n4723
XU4345 MAOI22D0BWP7T $PINS A2=n3642 ZN=n737 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__1_ VSS=VSS
XU4344 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3642 A2=n4723
XU4343 MAOI22D0BWP7T $PINS A2=n3640 ZN=n738 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__0_ VSS=VSS
XU4342 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3640 A2=n4723
XU4340 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3586 A1=n3637 ZN=n739 A2=n3657
XU4339 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__7_ A2=SA_A_2_shift_reg_4__7_
+ ZN=n3586 A1=n4693 VDD=VDD B2=n3637 VSS=VSS
XU4338 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3657 A2=n4723
XU4334 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3582 A1=n3584 ZN=n740 A2=n4829
XU4333 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3582 A1=SA_row_3<7> VDD=VDD
+ B2=SA_A_3_shift_reg_5__7_ VSS=VSS
XU4332 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3580 A1=n3581 ZN=n741 A2=n4829
XU4331 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3580 A1=SA_row_3<6> VDD=VDD
+ B2=SA_A_3_shift_reg_5__6_ VSS=VSS
XU4330 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3578 A1=n3579 ZN=n742 A2=n4829
XU4329 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3578 A1=SA_row_3<5> VDD=VDD
+ B2=SA_A_3_shift_reg_5__5_ VSS=VSS
XU4328 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3576 A1=n3577 ZN=n743 A2=n4829
XU4327 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3576 A1=SA_row_3<4> VDD=VDD
+ B2=SA_A_3_shift_reg_5__4_ VSS=VSS
XU4326 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3574 A1=n3575 ZN=n744 A2=n4829
XU4325 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3574 A1=SA_row_3<3> VDD=VDD
+ B2=SA_A_3_shift_reg_5__3_ VSS=VSS
XU4324 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3572 A1=n3573 ZN=n745 A2=n4829
XU4323 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3572 A1=SA_row_3<2> VDD=VDD
+ B2=SA_A_3_shift_reg_5__2_ VSS=VSS
XU4322 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3570 A1=n3571 ZN=n746 A2=n4829
XU4321 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3570 A1=SA_row_3<1> VDD=VDD
+ B2=SA_A_3_shift_reg_5__1_ VSS=VSS
XU4320 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3568 A1=n3569 ZN=n747 A2=n4829
XU4319 AOI22D0BWP7T $PINS B1=n4697 A2=n4829 ZN=n3568 A1=n4668 VDD=VDD
+ B2=SA_A_3_shift_reg_5__0_ VSS=VSS
XU4317 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3565 A1=n3566 ZN=n748 A2=n3581
XU4316 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__6_ A2=SA_A_3_shift_reg_4__6_
+ ZN=n3565 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4315 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3563 A1=n3566 ZN=n749 A2=n3579
XU4314 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__5_ A2=SA_A_3_shift_reg_4__5_
+ ZN=n3563 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4313 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3562 A1=n3566 ZN=n750 A2=n3577
XU4312 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__4_ A2=SA_A_3_shift_reg_4__4_
+ ZN=n3562 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4311 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3561 A1=n3566 ZN=n751 A2=n3575
XU4310 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__3_ A2=SA_A_3_shift_reg_4__3_
+ ZN=n3561 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4309 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3560 A1=n3566 ZN=n752 A2=n3573
XU4308 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__2_ A2=SA_A_3_shift_reg_4__2_
+ ZN=n3560 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4307 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3559 A1=n3566 ZN=n753 A2=n3571
XU4306 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__1_ A2=SA_A_3_shift_reg_4__1_
+ ZN=n3559 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4305 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3558 A1=n3566 ZN=n754 A2=n3569
XU4304 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_5__0_ A2=SA_A_3_shift_reg_4__0_
+ ZN=n3558 A1=n4697 VDD=VDD B2=n3566 VSS=VSS
XU4303 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3556 A1=n3584 ZN=n755 A2=n3557
XU4302 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__7_ A2=SA_A_3_shift_reg_3__7_
+ ZN=n3556 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4301 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3555 A1=n3581 ZN=n756 A2=n3557
XU4300 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__6_ A2=SA_A_3_shift_reg_3__6_
+ ZN=n3555 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4299 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3554 A1=n3579 ZN=n757 A2=n3557
XU4298 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__5_ A2=SA_A_3_shift_reg_3__5_
+ ZN=n3554 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4297 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3553 A1=n3577 ZN=n758 A2=n3557
XU4296 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__4_ A2=SA_A_3_shift_reg_3__4_
+ ZN=n3553 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4295 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3552 A1=n3575 ZN=n759 A2=n3557
XU4294 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__3_ A2=SA_A_3_shift_reg_3__3_
+ ZN=n3552 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4293 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3551 A1=n3573 ZN=n760 A2=n3557
XU4292 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__2_ A2=SA_A_3_shift_reg_3__2_
+ ZN=n3551 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4291 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3549 A1=n3571 ZN=n761 A2=n3557
XU4290 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__1_ A2=SA_A_3_shift_reg_3__1_
+ ZN=n3549 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4289 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3548 A1=n3569 ZN=n762 A2=n3557
XU4288 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_4__0_ A2=SA_A_3_shift_reg_3__0_
+ ZN=n3548 A1=n4697 VDD=VDD B2=n3557 VSS=VSS
XU4286 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3546 A1=n3584 ZN=n763 A2=n3547
XU4285 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__7_ A2=SA_A_3_shift_reg_2__7_
+ ZN=n3546 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4284 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3545 A1=n3581 ZN=n764 A2=n3547
XU4283 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__6_ A2=SA_A_3_shift_reg_2__6_
+ ZN=n3545 A1=n4697 VDD=VDD B2=n3547 VSS=VSS
XU4282 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3544 A1=n3579 ZN=n765 A2=n3547
XU4281 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__5_ A2=SA_A_3_shift_reg_2__5_
+ ZN=n3544 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4280 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3543 A1=n3577 ZN=n766 A2=n3547
XU4279 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__4_ A2=SA_A_3_shift_reg_2__4_
+ ZN=n3543 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4278 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3542 A1=n3575 ZN=n767 A2=n3547
XU4277 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__3_ A2=SA_A_3_shift_reg_2__3_
+ ZN=n3542 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4276 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3541 A1=n3573 ZN=n768 A2=n3547
XU4275 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__2_ A2=SA_A_3_shift_reg_2__2_
+ ZN=n3541 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4274 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3540 A1=n3571 ZN=n769 A2=n3547
XU4273 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__1_ A2=SA_A_3_shift_reg_2__1_
+ ZN=n3540 A1=n4697 VDD=VDD B2=n3547 VSS=VSS
XU4272 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3539 A1=n3569 ZN=n770 A2=n3547
XU4271 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_3__0_ A2=SA_A_3_shift_reg_2__0_
+ ZN=n3539 A1=n4702 VDD=VDD B2=n3547 VSS=VSS
XU4269 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3536 A1=n3584 ZN=n771 A2=n3537
XU4268 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__7_ A2=SA_A_3_shift_reg_1__7_
+ ZN=n3536 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4267 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3535 A1=n3581 ZN=n772 A2=n3537
XU4266 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__6_ A2=SA_A_3_shift_reg_1__6_
+ ZN=n3535 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4265 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3534 A1=n3579 ZN=n773 A2=n3537
XU4264 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__5_ A2=SA_A_3_shift_reg_1__5_
+ ZN=n3534 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4263 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3533 A1=n3577 ZN=n774 A2=n3537
XU4262 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__4_ A2=SA_A_3_shift_reg_1__4_
+ ZN=n3533 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4261 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3532 A1=n3575 ZN=n775 A2=n3537
XU4260 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__3_ A2=SA_A_3_shift_reg_1__3_
+ ZN=n3532 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4259 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3531 A1=n3573 ZN=n776 A2=n3537
XU4258 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__2_ A2=SA_A_3_shift_reg_1__2_
+ ZN=n3531 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4257 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3530 A1=n3571 ZN=n777 A2=n3537
XU4256 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__1_ A2=SA_A_3_shift_reg_1__1_
+ ZN=n3530 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4255 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3529 A1=n3569 ZN=n778 A2=n3537
XU4254 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_2__0_ A2=SA_A_3_shift_reg_1__0_
+ ZN=n3529 A1=n4702 VDD=VDD B2=n3537 VSS=VSS
XU4252 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3527 A1=n3584 ZN=n779 A2=n3528
XU4251 AOI22D0BWP7T $PINS B1=SA_A_3_shift_reg_1__7_ A2=SA_A_3_shift_reg_0__7_
+ ZN=n3527 A1=n4702 VDD=VDD B2=n3528 VSS=VSS
XU4250 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3526 A1=n3528 ZN=n780 A2=n3581
XU4451 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3649 A1=n3650 ZN=n687 A2=n3656
XU4450 AOI22D0BWP7T $PINS B1=n4697 A2=n3656 ZN=n3649 A1=SA_row_2<4> VDD=VDD
+ B2=SA_A_2_shift_reg_5__4_ VSS=VSS
XU4449 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3647 A1=n3648 ZN=n688 A2=n3656
XU4448 AOI22D0BWP7T $PINS B1=n4697 A2=n3656 ZN=n3647 A1=SA_row_2<3> VDD=VDD
+ B2=SA_A_2_shift_reg_5__3_ VSS=VSS
XU4446 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3644 A1=n3645 ZN=n689 A2=n3656
XU4445 AOI22D0BWP7T $PINS B1=n4693 A2=n3656 ZN=n3644 A1=SA_row_2<2> VDD=VDD
+ B2=SA_A_2_shift_reg_5__2_ VSS=VSS
XU4444 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3641 A1=n3642 ZN=n690 A2=n3656
XU4443 AOI22D1BWP7T $PINS B1=n4697 A2=n3656 ZN=n3641 A1=SA_row_2<1> VDD=VDD
+ B2=SA_A_2_shift_reg_5__1_ VSS=VSS
XU4442 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3639 A1=n3640 ZN=n691 A2=n3656
XU4441 AOI22D0BWP7T $PINS B1=n4697 A2=n3656 ZN=n3639 A1=SA_row_2<0> VDD=VDD
+ B2=SA_A_2_shift_reg_5__0_ VSS=VSS
XU4439 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3636 A1=n3637 ZN=n692 A2=n3654
XU4438 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__6_ A2=SA_A_2_shift_reg_4__6_
+ ZN=n3636 A1=n4697 VDD=VDD B2=n3637 VSS=VSS
XU4437 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3634 A1=n3637 ZN=n693 A2=n3652
XU4436 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__5_ A2=SA_A_2_shift_reg_4__5_
+ ZN=n3634 A1=n4693 VDD=VDD B2=n3637 VSS=VSS
XU4435 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3633 A1=n3637 ZN=n694 A2=n3650
XU4434 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__4_ A2=SA_A_2_shift_reg_4__4_
+ ZN=n3633 A1=n4697 VDD=VDD B2=n3637 VSS=VSS
XU4433 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3632 A1=n3637 ZN=n695 A2=n3648
XU4432 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__3_ A2=SA_A_2_shift_reg_4__3_
+ ZN=n3632 A1=n4697 VDD=VDD B2=n3637 VSS=VSS
XU4431 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3631 A1=n3637 ZN=n696 A2=n3645
XU4430 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__2_ A2=SA_A_2_shift_reg_4__2_
+ ZN=n3631 A1=n4693 VDD=VDD B2=n3637 VSS=VSS
XU4429 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3630 A1=n3637 ZN=n697 A2=n3642
XU4428 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__1_ A2=SA_A_2_shift_reg_4__1_
+ ZN=n3630 A1=n4697 VDD=VDD B2=n3637 VSS=VSS
XU4427 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3629 A1=n3637 ZN=n698 A2=n3640
XU4426 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_5__0_ A2=SA_A_2_shift_reg_4__0_
+ ZN=n3629 A1=n4697 VDD=VDD B2=n3637 VSS=VSS
XU4425 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3627 A1=n3657 ZN=n699 A2=n3628
XU4424 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__7_ A2=SA_A_2_shift_reg_3__7_
+ ZN=n3627 A1=n4693 VDD=VDD B2=n3628 VSS=VSS
XU4423 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3626 A1=n3654 ZN=n700 A2=n3628
XU4422 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__6_ A2=SA_A_2_shift_reg_3__6_
+ ZN=n3626 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4421 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3625 A1=n3652 ZN=n701 A2=n3628
XU4420 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__5_ A2=SA_A_2_shift_reg_3__5_
+ ZN=n3625 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4419 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3623 A1=n3650 ZN=n702 A2=n3628
XU4418 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__4_ A2=SA_A_2_shift_reg_3__4_
+ ZN=n3623 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4417 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3622 A1=n3648 ZN=n703 A2=n3628
XU4416 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__3_ A2=SA_A_2_shift_reg_3__3_
+ ZN=n3622 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4415 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3621 A1=n3645 ZN=n704 A2=n3628
XU4414 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__2_ A2=SA_A_2_shift_reg_3__2_
+ ZN=n3621 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4413 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3620 A1=n3642 ZN=n705 A2=n3628
XU4412 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__1_ A2=SA_A_2_shift_reg_3__1_
+ ZN=n3620 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4411 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3619 A1=n3640 ZN=n706 A2=n3628
XU4410 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_4__0_ A2=SA_A_2_shift_reg_3__0_
+ ZN=n3619 A1=n4697 VDD=VDD B2=n3628 VSS=VSS
XU4408 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3617 A1=n3657 ZN=n707 A2=n3618
XU4407 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__7_ A2=SA_A_2_shift_reg_2__7_
+ ZN=n3617 A1=n4701 VDD=VDD B2=n3618 VSS=VSS
XU4406 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3616 A1=n3654 ZN=n708 A2=n3618
XU4405 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__6_ A2=SA_A_2_shift_reg_2__6_
+ ZN=n3616 A1=n4697 VDD=VDD B2=n3618 VSS=VSS
XU4404 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3615 A1=n3652 ZN=n709 A2=n3618
XU4403 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__5_ A2=SA_A_2_shift_reg_2__5_
+ ZN=n3615 A1=n4701 VDD=VDD B2=n3618 VSS=VSS
XU4402 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3614 A1=n3650 ZN=n710 A2=n3618
XU4401 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__4_ A2=SA_A_2_shift_reg_2__4_
+ ZN=n3614 A1=n4697 VDD=VDD B2=n3618 VSS=VSS
XU4400 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3613 A1=n3648 ZN=n711 A2=n3618
XU4399 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__3_ A2=SA_A_2_shift_reg_2__3_
+ ZN=n3613 A1=n4697 VDD=VDD B2=n3618 VSS=VSS
XU4398 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3612 A1=n3645 ZN=n712 A2=n3618
XU4397 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__2_ A2=SA_A_2_shift_reg_2__2_
+ ZN=n3612 A1=n4701 VDD=VDD B2=n3618 VSS=VSS
XU4396 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3611 A1=n3642 ZN=n713 A2=n3618
XU4395 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__1_ A2=SA_A_2_shift_reg_2__1_
+ ZN=n3611 A1=n4697 VDD=VDD B2=n3618 VSS=VSS
XU4393 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3609 A1=n3640 ZN=n714 A2=n3618
XU4392 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_3__0_ A2=SA_A_2_shift_reg_2__0_
+ ZN=n3609 A1=n4697 VDD=VDD B2=n3618 VSS=VSS
XU4390 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3606 A1=n3657 ZN=n715 A2=n3607
XU4389 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__7_ A2=SA_A_2_shift_reg_1__7_
+ ZN=n3606 A1=n4701 VDD=VDD B2=n3607 VSS=VSS
XU4388 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3605 A1=n3654 ZN=n716 A2=n3607
XU4387 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__6_ A2=SA_A_2_shift_reg_1__6_
+ ZN=n3605 A1=n4697 VDD=VDD B2=n3607 VSS=VSS
XU4386 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3604 A1=n3652 ZN=n717 A2=n3607
XU4385 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__5_ A2=SA_A_2_shift_reg_1__5_
+ ZN=n3604 A1=n4701 VDD=VDD B2=n3607 VSS=VSS
XU4384 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3603 A1=n3650 ZN=n718 A2=n3607
XU4383 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__4_ A2=SA_A_2_shift_reg_1__4_
+ ZN=n3603 A1=n4701 VDD=VDD B2=n3607 VSS=VSS
XU4382 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3602 A1=n3648 ZN=n719 A2=n3607
XU4381 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__3_ A2=SA_A_2_shift_reg_1__3_
+ ZN=n3602 A1=n4697 VDD=VDD B2=n3607 VSS=VSS
XU4380 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3601 A1=n3645 ZN=n720 A2=n3607
XU4379 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__2_ A2=SA_A_2_shift_reg_1__2_
+ ZN=n3601 A1=n4701 VDD=VDD B2=n3607 VSS=VSS
XU4378 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3600 A1=n3642 ZN=n721 A2=n3607
XU4377 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__1_ A2=SA_A_2_shift_reg_1__1_
+ ZN=n3600 A1=n4697 VDD=VDD B2=n3607 VSS=VSS
XU4376 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3599 A1=n3640 ZN=n722 A2=n3607
XU4375 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_2__0_ A2=SA_A_2_shift_reg_1__0_
+ ZN=n3599 A1=n4697 VDD=VDD B2=n3607 VSS=VSS
XU4373 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3597 A1=n3657 ZN=n723 A2=n3598
XU4372 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__7_ A2=SA_A_2_shift_reg_0__7_
+ ZN=n3597 A1=n4701 VDD=VDD B2=n3598 VSS=VSS
XU4371 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3596 A1=n3598 ZN=n724 A2=n3654
XU4370 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__6_ A2=SA_A_2_shift_reg_0__6_
+ ZN=n3596 A1=n4702 VDD=VDD B2=n3598 VSS=VSS
XU4369 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3594 A1=n3598 ZN=n725 A2=n3652
XU4368 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__5_ A2=SA_A_2_shift_reg_0__5_
+ ZN=n3594 A1=n4701 VDD=VDD B2=n3598 VSS=VSS
XU4367 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3593 A1=n3598 ZN=n726 A2=n3650
XU4366 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__4_ A2=SA_A_2_shift_reg_0__4_
+ ZN=n3593 A1=n4697 VDD=VDD B2=n3598 VSS=VSS
XU4365 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3592 A1=n3598 ZN=n727 A2=n3648
XU4364 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__3_ A2=SA_A_2_shift_reg_0__3_
+ ZN=n3592 A1=n4702 VDD=VDD B2=n3598 VSS=VSS
XU4363 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3591 A1=n3598 ZN=n728 A2=n3645
XU4362 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__2_ A2=SA_A_2_shift_reg_0__2_
+ ZN=n3591 A1=n4701 VDD=VDD B2=n3598 VSS=VSS
XU4361 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3590 A1=n3598 ZN=n729 A2=n3642
XU4360 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__1_ A2=SA_A_2_shift_reg_0__1_
+ ZN=n3590 A1=n4702 VDD=VDD B2=n3598 VSS=VSS
XU4359 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3589 A1=n3598 ZN=n730 A2=n3640
XU4358 AOI22D0BWP7T $PINS B1=SA_A_2_shift_reg_1__0_ A2=SA_A_2_shift_reg_0__0_
+ ZN=n3589 A1=n4702 VDD=VDD B2=n3598 VSS=VSS
XU4356 MAOI22D0BWP7T $PINS A2=n3657 ZN=n731 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__7_ VSS=VSS
XU4355 MAOI22D0BWP7T $PINS A2=n3654 ZN=n732 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__6_ VSS=VSS
XU4354 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3654 A2=n4723
XU4353 MAOI22D0BWP7T $PINS A2=n3652 ZN=n733 A1=n3588 B2=n3588 VDD=VDD
+ B1=SA_A_2_shift_reg_0__5_ VSS=VSS
XU4352 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3652 A2=n4723
XU4554 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__2_ A2=SA_A_1_shift_reg_4__2_
+ ZN=n3714 A1=n4701 VDD=VDD B2=n3720 VSS=VSS
XU4553 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3713 A1=n3720 ZN=n641 A2=n3726
XU4552 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__1_ A2=SA_A_1_shift_reg_4__1_
+ ZN=n3713 A1=n4701 VDD=VDD B2=n3720 VSS=VSS
XU4551 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3711 A1=n3720 ZN=n642 A2=n3724
XU4550 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__0_ A2=SA_A_1_shift_reg_4__0_
+ ZN=n3711 A1=n4693 VDD=VDD B2=n3720 VSS=VSS
XU4549 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3709 A1=n3741 ZN=n643 A2=n3710
XU4548 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__7_ A2=SA_A_1_shift_reg_3__7_
+ ZN=n3709 A1=n4701 VDD=VDD B2=n3710 VSS=VSS
XU4547 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3708 A1=n3737 ZN=n644 A2=n3710
XU4546 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__6_ A2=SA_A_1_shift_reg_3__6_
+ ZN=n3708 A1=n4701 VDD=VDD B2=n3710 VSS=VSS
XU4545 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3707 A1=n3734 ZN=n645 A2=n3710
XU4544 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__5_ A2=SA_A_1_shift_reg_3__5_
+ ZN=n3707 A1=n4693 VDD=VDD B2=n3710 VSS=VSS
XU4543 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3706 A1=n3732 ZN=n646 A2=n3710
XU4542 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__4_ A2=SA_A_1_shift_reg_3__4_
+ ZN=n3706 A1=n4693 VDD=VDD B2=n3710 VSS=VSS
XU4541 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3705 A1=n3730 ZN=n647 A2=n3710
XU4540 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__3_ A2=SA_A_1_shift_reg_3__3_
+ ZN=n3705 A1=n4693 VDD=VDD B2=n3710 VSS=VSS
XU4539 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3704 A1=n3728 ZN=n648 A2=n3710
XU4538 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__2_ A2=SA_A_1_shift_reg_3__2_
+ ZN=n3704 A1=n4701 VDD=VDD B2=n3710 VSS=VSS
XU4537 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3703 A1=n3726 ZN=n649 A2=n3710
XU4536 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__1_ A2=SA_A_1_shift_reg_3__1_
+ ZN=n3703 A1=n4701 VDD=VDD B2=n3710 VSS=VSS
XU4535 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3702 A1=n3724 ZN=n650 A2=n3710
XU4534 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_4__0_ A2=SA_A_1_shift_reg_3__0_
+ ZN=n3702 A1=n4693 VDD=VDD B2=n3710 VSS=VSS
XU4532 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3699 A1=n3741 ZN=n651 A2=n3700
XU4531 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__7_ A2=SA_A_1_shift_reg_2__7_
+ ZN=n3699 A1=n4701 VDD=VDD B2=n3700 VSS=VSS
XU4530 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3698 A1=n3737 ZN=n652 A2=n3700
XU4529 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__6_ A2=SA_A_1_shift_reg_2__6_
+ ZN=n3698 A1=n4701 VDD=VDD B2=n3700 VSS=VSS
XU4528 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3697 A1=n3734 ZN=n653 A2=n3700
XU4527 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__5_ A2=SA_A_1_shift_reg_2__5_
+ ZN=n3697 A1=n4693 VDD=VDD B2=n3700 VSS=VSS
XU4525 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3695 A1=n3732 ZN=n654 A2=n3700
XU4524 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__4_ A2=SA_A_1_shift_reg_2__4_
+ ZN=n3695 A1=n4693 VDD=VDD B2=n3700 VSS=VSS
XU4523 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3693 A1=n3730 ZN=n655 A2=n3700
XU4522 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__3_ A2=SA_A_1_shift_reg_2__3_
+ ZN=n3693 A1=n4693 VDD=VDD B2=n3700 VSS=VSS
XU4521 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3692 A1=n3728 ZN=n656 A2=n3700
XU4520 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__2_ A2=SA_A_1_shift_reg_2__2_
+ ZN=n3692 A1=n4701 VDD=VDD B2=n3700 VSS=VSS
XU4519 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3691 A1=n3726 ZN=n657 A2=n3700
XU4518 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__1_ A2=SA_A_1_shift_reg_2__1_
+ ZN=n3691 A1=n4701 VDD=VDD B2=n3700 VSS=VSS
XU4517 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3690 A1=n3724 ZN=n658 A2=n3700
XU4516 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_3__0_ A2=SA_A_1_shift_reg_2__0_
+ ZN=n3690 A1=n4693 VDD=VDD B2=n3700 VSS=VSS
XU4514 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3687 A1=n3741 ZN=n659 A2=n3688
XU4513 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__7_ A2=SA_A_1_shift_reg_1__7_
+ ZN=n3687 A1=n4701 VDD=VDD B2=n3688 VSS=VSS
XU4512 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3686 A1=n3737 ZN=n660 A2=n3688
XU4511 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__6_ A2=SA_A_1_shift_reg_1__6_
+ ZN=n3686 A1=n4701 VDD=VDD B2=n3688 VSS=VSS
XU4510 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3685 A1=n3734 ZN=n661 A2=n3688
XU4509 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__5_ A2=SA_A_1_shift_reg_1__5_
+ ZN=n3685 A1=n4693 VDD=VDD B2=n3688 VSS=VSS
XU4508 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3684 A1=n3732 ZN=n662 A2=n3688
XU4507 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__4_ A2=SA_A_1_shift_reg_1__4_
+ ZN=n3684 A1=n4693 VDD=VDD B2=n3688 VSS=VSS
XU4506 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3683 A1=n3730 ZN=n663 A2=n3688
XU4505 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__3_ A2=SA_A_1_shift_reg_1__3_
+ ZN=n3683 A1=n4701 VDD=VDD B2=n3688 VSS=VSS
XU4504 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3682 A1=n3728 ZN=n664 A2=n3688
XU4503 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__2_ A2=SA_A_1_shift_reg_1__2_
+ ZN=n3682 A1=n4701 VDD=VDD B2=n3688 VSS=VSS
XU4502 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3681 A1=n3726 ZN=n665 A2=n3688
XU4501 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__1_ A2=SA_A_1_shift_reg_1__1_
+ ZN=n3681 A1=n4701 VDD=VDD B2=n3688 VSS=VSS
XU4500 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3680 A1=n3724 ZN=n666 A2=n3688
XU4499 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_2__0_ A2=SA_A_1_shift_reg_1__0_
+ ZN=n3680 A1=n4693 VDD=VDD B2=n3688 VSS=VSS
XU4496 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3676 A1=n3741 ZN=n667 A2=n3677
XU4495 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__7_ A2=SA_A_1_shift_reg_0__7_
+ ZN=n3676 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4494 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3674 A1=n3677 ZN=n668 A2=n3737
XU4493 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__6_ A2=SA_A_1_shift_reg_0__6_
+ ZN=n3674 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4492 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3673 A1=n3677 ZN=n669 A2=n3734
XU4491 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__5_ A2=SA_A_1_shift_reg_0__5_
+ ZN=n3673 A1=n4693 VDD=VDD B2=n3677 VSS=VSS
XU4490 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3672 A1=n3677 ZN=n670 A2=n3732
XU4489 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__4_ A2=SA_A_1_shift_reg_0__4_
+ ZN=n3672 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4488 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3671 A1=n3677 ZN=n671 A2=n3730
XU4487 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__3_ A2=SA_A_1_shift_reg_0__3_
+ ZN=n3671 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4486 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3670 A1=n3677 ZN=n672 A2=n3728
XU4485 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__2_ A2=SA_A_1_shift_reg_0__2_
+ ZN=n3670 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4484 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3669 A1=n3677 ZN=n673 A2=n3726
XU4483 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__1_ A2=SA_A_1_shift_reg_0__1_
+ ZN=n3669 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4482 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3668 A1=n3677 ZN=n674 A2=n3724
XU4481 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_1__0_ A2=SA_A_1_shift_reg_0__0_
+ ZN=n3668 A1=n4701 VDD=VDD B2=n3677 VSS=VSS
XU4479 MAOI22D0BWP7T $PINS A2=n3741 ZN=n675 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__7_ VSS=VSS
XU4478 MAOI22D0BWP7T $PINS A2=n3737 ZN=n676 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__6_ VSS=VSS
XU4477 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4502 ZN=n3737 A2=n4724
XU4476 MAOI22D0BWP7T $PINS A2=n3734 ZN=n677 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__5_ VSS=VSS
XU4475 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4503 ZN=n3734 A2=n4724
XU4474 MAOI22D0BWP7T $PINS A2=n3732 ZN=n678 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__4_ VSS=VSS
XU4473 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4504 ZN=n3732 A2=n4724
XU4472 MAOI22D0BWP7T $PINS A2=n3730 ZN=n679 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__3_ VSS=VSS
XU4471 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3730 A2=n4724
XU4470 MAOI22D0BWP7T $PINS A2=n3728 ZN=n680 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__2_ VSS=VSS
XU4469 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4506 ZN=n3728 A2=n4724
XU4468 MAOI22D0BWP7T $PINS A2=n3726 ZN=n681 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__1_ VSS=VSS
XU4467 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4507 ZN=n3726 A2=n4724
XU4466 MAOI22D0BWP7T $PINS A2=n3724 ZN=n682 A1=n3666 B2=n3666 VDD=VDD
+ B1=SA_A_1_shift_reg_0__0_ VSS=VSS
XU4465 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4508 ZN=n3724 A2=n4724
XU4463 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3663 A1=n3720 ZN=n683 A2=n3741
XU4462 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__7_ A2=SA_A_1_shift_reg_4__7_
+ ZN=n3663 A1=n4701 VDD=VDD B2=n3720 VSS=VSS
XU4461 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4501 ZN=n3741 A2=n4724
XU4457 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3655 A1=n3657 ZN=n684 A2=n3656
XU4456 AOI22D0BWP7T $PINS B1=n4693 A2=n3656 ZN=n3655 A1=SA_row_2<7> VDD=VDD
+ B2=SA_A_2_shift_reg_5__7_ VSS=VSS
XU4455 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3653 A1=n3654 ZN=n685 A2=n3656
XU4454 AOI22D0BWP7T $PINS B1=n4697 A2=n3656 ZN=n3653 A1=SA_row_2<6> VDD=VDD
+ B2=SA_A_2_shift_reg_5__6_ VSS=VSS
XU4453 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3651 A1=n3652 ZN=n686 A2=n3656
XU4452 AOI22D0BWP7T $PINS B1=n4693 A2=n3656 ZN=n3651 A1=SA_row_2<5> VDD=VDD
+ B2=SA_A_2_shift_reg_5__5_ VSS=VSS
Xicc_place1512 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4566 ZN=n4567
Xicc_place1514 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4568 ZN=n4569
Xicc_place1570 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4831 ZN=n4625
Xicc_place1516 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4570 ZN=n4571
Xicc_place1629 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<176> ZN=n4684
Xicc_place1626 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<32> ZN=n4681
Xicc_place1569 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<56> ZN=n4624
Xicc_place1518 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4572 ZN=n4573
Xicc_place1621 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4820 ZN=n4676
Xicc_place1535 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<138> Z=n4590
Xicc_place1537 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<130> Z=n4592
XU3377 AOI21D1BWP7T $PINS VSS=VSS A2=n3844 VDD=VDD A1=n2963 B=n2975 ZN=n2969
XU2308 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1922 B=n1952 A2=n1889
+ A1=SA_core_shift_wire<61>
XU1640 AOI21D0BWP7T $PINS VSS=VSS A2=n1241 VDD=VDD A1=n4525 B=n1252 ZN=n1246
XU1764 AOI21D0BWP7T $PINS VSS=VSS A2=n1358 VDD=VDD A1=n1359 B=n1370 ZN=n1364
XU2267 AOI21D0BWP7T $PINS VSS=VSS A2=n1851 VDD=VDD A1=n1852 B=n1863 ZN=n1857
XU2252 INVD2BWP7T $PINS ZN=n3843 VSS=VSS VDD=VDD I=SA_core_shift_wire<83>
XU3625 INVD0BWP7T $PINS ZN=n3994 VSS=VSS VDD=VDD I=n1534
XU3616 INVD0BWP7T $PINS ZN=n3993 VSS=VSS VDD=VDD I=n2024
XU3604 INVD0BWP7T $PINS ZN=n3991 VSS=VSS VDD=VDD I=n1266
XU3603 INVD0BWP7T $PINS ZN=n3990 VSS=VSS VDD=VDD I=n1385
XU3590 INVD0BWP7T $PINS ZN=n3989 VSS=VSS VDD=VDD I=n4170
XU3017 INVD0BWP7T $PINS ZN=n3916 VSS=VSS VDD=VDD I=n2853
XU2743 INVD0BWP7T $PINS ZN=n3887 VSS=VSS VDD=VDD I=SA_col_2<6>
XU2632 INVD1BWP7T $PINS ZN=n3881 VSS=VSS VDD=VDD I=SA_col_1<5>
XU2614 INVD0BWP7T $PINS ZN=n3873 VSS=VSS VDD=VDD I=SA_col_0<6>
XU2254 INVD0BWP7T $PINS ZN=n3844 VSS=VSS VDD=VDD I=SA_core_output_row_3<1>
XU2250 INVD0BWP7T $PINS ZN=n3842 VSS=VSS VDD=VDD I=SA_core_output_row_3<3>
XU2246 INVD1BWP7T $PINS ZN=n3840 VSS=VSS VDD=VDD I=SA_core_output_row_3<4>
XU2240 INVD0BWP7T $PINS ZN=n3839 VSS=VSS VDD=VDD I=SA_core_output_row_3<5>
XU1985 CKND2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<106> ZN=n3813
XU1887 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<33> ZN=n3805
XU1670 INVD0BWP7T $PINS ZN=n3786 VSS=VSS VDD=VDD I=SA_core_connect<188>
XU1576 INVD1BWP7T $PINS ZN=n3774 VSS=VSS VDD=VDD I=SA_core_connect<163>
XU1510 INVD0BWP7T $PINS ZN=n3771 VSS=VSS VDD=VDD I=SA_core_connect<164>
XU1507 INVD1BWP7T $PINS ZN=n3770 VSS=VSS VDD=VDD I=SA_core_connect<149>
XU1501 INVD0BWP7T $PINS ZN=n3768 VSS=VSS VDD=VDD I=SA_core_output_row_0<3>
XU1499 INVD0BWP7T $PINS ZN=n3767 VSS=VSS VDD=VDD I=SA_core_output_row_0<4>
XU1497 INVD0BWP7T $PINS ZN=n3766 VSS=VSS VDD=VDD I=SA_core_output_row_0<5>
XU4580 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3739 A1=n3741 ZN=n627 A2=n3740
XU4579 AOI22D0BWP7T $PINS B1=n4701 A2=n3740 ZN=n3739 A1=SA_row_1<7> VDD=VDD
+ B2=SA_A_1_shift_reg_5__7_ VSS=VSS
XU4578 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3736 A1=n3737 ZN=n629 A2=n3740
XU4577 AOI22D0BWP7T $PINS B1=n4701 A2=n3740 ZN=n3736 A1=SA_row_1<6> VDD=VDD
+ B2=SA_A_1_shift_reg_5__6_ VSS=VSS
XU4576 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3733 A1=n3734 ZN=n630 A2=n3740
XU4575 AOI22D0BWP7T $PINS B1=n4693 A2=n3740 ZN=n3733 A1=SA_row_1<5> VDD=VDD
+ B2=SA_A_1_shift_reg_5__5_ VSS=VSS
XU4574 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3731 A1=n3732 ZN=n631 A2=n3740
XU4573 AOI22D0BWP7T $PINS B1=n4693 A2=n3740 ZN=n3731 A1=SA_row_1<4> VDD=VDD
+ B2=SA_A_1_shift_reg_5__4_ VSS=VSS
XU4572 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3729 A1=n3730 ZN=n632 A2=n3740
XU4571 AOI22D0BWP7T $PINS B1=n4693 A2=n3740 ZN=n3729 A1=SA_row_1<3> VDD=VDD
+ B2=SA_A_1_shift_reg_5__3_ VSS=VSS
XU4570 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3727 A1=n3728 ZN=n633 A2=n3740
XU4569 AOI22D0BWP7T $PINS B1=n4701 A2=n3740 ZN=n3727 A1=SA_row_1<2> VDD=VDD
+ B2=SA_A_1_shift_reg_5__2_ VSS=VSS
XU4568 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3725 A1=n3726 ZN=n634 A2=n3740
XU4567 AOI22D0BWP7T $PINS B1=n4693 A2=n3740 ZN=n3725 A1=SA_row_1<1> VDD=VDD
+ B2=SA_A_1_shift_reg_5__1_ VSS=VSS
XU4566 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3723 A1=n3724 ZN=n635 A2=n3740
XU4565 AOI22D0BWP7T $PINS B1=n4693 A2=n3740 ZN=n3723 A1=SA_row_1<0> VDD=VDD
+ B2=SA_A_1_shift_reg_5__0_ VSS=VSS
XU4563 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3719 A1=n3720 ZN=n636 A2=n3737
XU4562 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__6_ A2=SA_A_1_shift_reg_4__6_
+ ZN=n3719 A1=n4701 VDD=VDD B2=n3720 VSS=VSS
XU4561 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3717 A1=n3720 ZN=n637 A2=n3734
XU4560 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__5_ A2=SA_A_1_shift_reg_4__5_
+ ZN=n3717 A1=n4693 VDD=VDD B2=n3720 VSS=VSS
XU4559 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3716 A1=n3720 ZN=n638 A2=n3732
XU4558 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__4_ A2=SA_A_1_shift_reg_4__4_
+ ZN=n3716 A1=n4693 VDD=VDD B2=n3720 VSS=VSS
XU4557 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3715 A1=n3720 ZN=n639 A2=n3730
XU4556 AOI22D0BWP7T $PINS B1=SA_A_1_shift_reg_5__3_ A2=SA_A_1_shift_reg_4__3_
+ ZN=n3715 A1=n4693 VDD=VDD B2=n3720 VSS=VSS
XU4555 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3714 A1=n3720 ZN=n640 A2=n3728
Xicc_place1547 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4601 ZN=n4602
Xicc_place1636 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<16> ZN=n4691
Xicc_place1542 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4596 ZN=n4597
Xicc_place1544 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<154> Z=n4599
Xicc_place1625 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4825 ZN=n4680
XU1471 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4814 ZN=n3749
XU1472 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<17> ZN=n3750
XU1483 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4838 ZN=n3759
XU1623 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<146> ZN=n3779
XU1984 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<114> ZN=n3812
XU1473 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<9> ZN=n3751
XU4812 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n4651 ZN=n4249 A1=n4462 B2=n4654
XU4772 INVD0BWP7T $PINS ZN=n4204 VSS=VSS VDD=VDD I=n2359
XU4771 INVD0BWP7T $PINS ZN=n4203 VSS=VSS VDD=VDD I=n4204
XU4760 INVD0BWP7T $PINS ZN=n4192 VSS=VSS VDD=VDD I=n1090
XU4759 OA32D0BWP7T $PINS VSS=VSS A1=SA_ctrl_state_compute_out<0> VDD=VDD
+ A2=n4712 A3=n3140 B2=n3091 B1=n3092 Z=n1090
XU4745 INVD0BWP7T $PINS ZN=n4178 VSS=VSS VDD=VDD I=n2991
XU4743 INVD0BWP7T $PINS ZN=n4176 VSS=VSS VDD=VDD I=n2248
XU4735 INVD0BWP7T $PINS ZN=n4168 VSS=VSS VDD=VDD I=n1088
XU4734 OA32D0BWP7T $PINS VSS=VSS A1=n4740 VDD=VDD A2=ack A3=n4705 B2=n3098
+ B1=n4656 Z=n1088
XU4733 INVD0BWP7T $PINS ZN=n4167 VSS=VSS VDD=VDD I=n1078
XU4732 OA32D0BWP7T $PINS VSS=VSS A1=n4653 VDD=VDD A2=n4741 A3=n3129 B2=n4654
+ B1=n3128 Z=n1078
XU4730 INVD0BWP7T $PINS ZN=n4165 VSS=VSS VDD=VDD I=n2516
XU2502 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n4725 ZN=n2538 A2=n4830
XU2266 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1863 A1=n4626 A3=n1852 A2=n4680
XU4348 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4505 ZN=n3648 A2=n4723
XU2378 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_0_N21 A2=n3863
XU1428 TIEHBWP7T $PINS VSS=VSS VDD=VDD Z=n628
XU1427 TIELBWP7T $PINS VSS=VSS VDD=VDD ZN=SA_ctrl__Logic0_
XU3437 OAI22D2BWP7T $PINS B1=n4746 A2=n3019 ZN=SA_core_pe_3_3_N15 A1=n3086
+ VDD=VDD B2=n4523 VSS=VSS
XU2648 AOI21D0BWP7T $PINS VSS=VSS A2=n2222 VDD=VDD A1=n2223 B=n2234 ZN=n2228
XU2774 AOI21D1BWP7T $PINS VSS=VSS A2=n2343 VDD=VDD A1=n2344 B=n2355 ZN=n2349
XU1860 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<184> ZN=n3797
XU2447 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_1<3> ZN=n3857
XU2492 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_2<5> ZN=n3861
XU2500 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_2<3> ZN=n3863
XU2517 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<3> ZN=n3869
XU2616 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_0<5> ZN=n3874
XU2620 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_0<3> ZN=n3876
XU2675 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_1<3> ZN=n3883
XU2753 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_2<3> ZN=n3890
XU2801 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_3<3> ZN=n3895
XU2510 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<4> ZN=n3868
XU2863 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_3<2> ZN=n3896
XU2486 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_1<2> ZN=n3858
XU1478 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<124> ZN=n3755
XU1515 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<156> ZN=n3772
XU1517 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<148> ZN=n3773
XU1671 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4811 ZN=n3787
XU2117 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<157> ZN=n1798
XU1872 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<6> ZN=n1536
XU2358 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<3> ZN=n3847
XU2379 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_1<5> ZN=n3855
XU2509 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_3<5> ZN=n3867
XU1991 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<180> ZN=n1674
XU2364 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<108> ZN=n2034
XU2871 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<100> ZN=n2526
XU1615 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<155> ZN=n3775
XU1617 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<147> ZN=n3776
XU1619 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<162> ZN=n3777
XU1678 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<179> ZN=n3789
XU1741 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4848 ZN=n3790
XU1743 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<186> ZN=n3791
XU1866 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<35> ZN=n3800
XU1868 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<27> ZN=n3801
XU2004 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<59> ZN=n3819
XU2381 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_1<4> ZN=n3856
XU2022 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4845 ZN=n1673
XU1469 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<11> ZN=n3747
XU1470 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<18> ZN=n3748
XU1479 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<131> ZN=n3756
XU2015 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<50> ZN=n3822
XU2042 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<65> ZN=n3823
XU2232 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<73> ZN=n3835
XU2360 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<2> ZN=n3848
XU1647 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<160> ZN=n3783
XU1880 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4833 ZN=n3804
XU1982 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<115> ZN=n3810
Xicc_place1550 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<178> Z=n4605
Xicc_place1552 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<170> Z=n4607
Xicc_place1630 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_3<0> ZN=n4685
Xicc_place1617 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4672 I=SA_col_2<2>
Xicc_place1572 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<145> ZN=n4627
Xicc_place1593 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<64> ZN=n4648
XU3655 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3205 ZN=n3193 A2=n3701
XU3633 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3205 ZN=n3182 A2=n3689
XU3610 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3205 ZN=n3171 A2=n3678
XU3586 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3205 ZN=n3160 A2=n4713
XU4726 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n4341 B=n4707 A2=n3183 A1=n4772
XU3569 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4341 ZN=n3149 A1=n3205
XU3531 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4704 A1=SA_ctrl_state_overall<1>
+ ZN=n3128 A2=n3116
XU3494 AOI22D1BWP7T $PINS B1=n3249 A2=n3106 ZN=n3094
+ A1=SA_ctrl_state_overall<1> VDD=VDD B2=n4711 VSS=VSS
XU1429 INVD1BWP7T $PINS ZN=n3089 VSS=VSS VDD=VDD I=SA_ctrl_state_compute_out<1>
XU3480 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4704 ZN=n3092 A3=n3131 A2=n4708
+ A1=n3134
XU1431 NR3D4BWP7T $PINS VSS=VSS VDD=VDD ZN=n3087 A1=n3089
+ A3=SA_ctrl_state_compute_out<0> A2=n4708
XU2241 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N30 A2=n4587
XU2239 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N29 A2=n3756
XU2237 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N28 A2=n4593
XU2235 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N27 A2=n4626
XU2233 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4728 ZN=SA_core_pe_2_1_N26 A2=n4597
XU3382 OAI22D1BWP7T $PINS B1=n4746 A2=n2966 ZN=SA_core_pe_3_3_N11 A1=n3086
+ VDD=VDD B2=n4525 VSS=VSS
XU3961 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3365 A1=n3367 ZN=n908 A2=n3366
XU3824 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3282 A1=n3283 ZN=n970 A2=n3295
XU3543 AOI221D1BWP7T $PINS B2=n3144 A1=SA_ctrl_state_overall<1> A2=n3144
+ ZN=n1079 B1=n4703 VDD=VDD C=n4705 VSS=VSS
XU3482 OAI22D1BWP7T $PINS B1=n3089 A2=n4510 ZN=n1091 A1=n3090 VDD=VDD B2=n3092
+ VSS=VSS
XU1443 AOI22D0BWP7T $PINS B1=n4830 A2=SA_core_output_row_2<2> ZN=n1097 A1=n4816
+ VDD=VDD B2=SA_core_output_row_1<2> VSS=VSS
XSA_core_pe_1_0_Bij_o_reg_0_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_1_0_N26 Q=SA_core_connect<104> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_3_N32 Q=SA_core_connect<174> VDD=VDD
XSA_core_pe_0_0_Cij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N14 Q=SA_core_shift_wire<4> VDD=VDD
XSA_core_pe_0_2_Bij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_2_N33 Q=SA_core_connect<151> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_3_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_0_N21 Q=SA_core_connect<27> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_6_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N24 Q=SA_core_connect<30> VDD=VDD
XSA_core_pe_2_0_Aij_o_reg_3_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_2_0_N21 Q=SA_core_connect<51> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_2_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_2_N20 Q=SA_core_connect<66> VDD=VDD
XSA_core_pe_0_0_Bij_o_reg_6_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5
+ D=SA_core_pe_0_0_N32 Q=SA_core_connect<102> VDD=VDD
XSA_core_pe_1_0_Cij_o_reg_7_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_1_0_N17 Q=SA_core_shift_wire<31> VDD=VDD
XSA_core_pe_2_2_Bij_o_reg_4_ DFQD0BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_2_N30 Q=SA_core_connect<164> VDD=VDD
XU2634 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4818 ZN=n2283
XU2762 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_3<4> ZN=n3894
XU4996 AOI21D0BWP7T $PINS VSS=VSS A2=n3844 VDD=VDD A1=n2963 B=n2975 ZN=n4451
XU4994 AOI21D1BWP7T $PINS VSS=VSS A2=n2343 VDD=VDD A1=n2344 B=n2355 ZN=n4449
XU4993 AOI21D1BWP7T $PINS VSS=VSS A2=n2222 VDD=VDD A1=n2223 B=n2234 ZN=n4448
XU4992 AOI21D1BWP7T $PINS VSS=VSS A2=n2099 VDD=VDD A1=n2100 B=n2112 ZN=n4447
XU4991 AOI21D1BWP7T $PINS VSS=VSS A2=n1851 VDD=VDD A1=n1852 B=n1863 ZN=n4446
XU4989 AOI21D1BWP7T $PINS VSS=VSS A2=n1358 VDD=VDD A1=n1359 B=n1370 ZN=n4444
XU4988 AOI21D1BWP7T $PINS VSS=VSS A2=n1241 VDD=VDD A1=n4525 B=n1252 ZN=n4443
XU4966 INVD0BWP7T $PINS ZN=n4421 VSS=VSS VDD=VDD I=n4460
XU4963 INVD0BWP7T $PINS ZN=n4418 VSS=VSS VDD=VDD I=n4756
XU4714 IAO21D0BWP7T $PINS VSS=VSS VDD=VDD A2=n3183 B=n4707 A1=n4772 ZN=n4340
XU1512 INVD0BWP7T $PINS ZN=n1116 VSS=VSS VDD=VDD I=SA_core_shift_wire<0>
XU1467 OAI21D2BWP7T $PINS A2=n3172 A1=n3514 ZN=n4476 VDD=VDD B=n4509 VSS=VSS
XU3585 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n3667 A3=n4665 A2=n4772
+ A1=SA_ctrl_state_load_id<1>
XU3708 OAI21D1BWP7T $PINS B=n4706 A2=n3442 ZN=n3279 VDD=VDD A1=n3514 VSS=VSS
XU3654 OAI21D2BWP7T $PINS A2=n4655 A1=n3183 ZN=n3701 VDD=VDD B=n4706 VSS=VSS
XU4713 OAI21D2BWP7T $PINS A2=n4655 A1=n3183 ZN=n4345 VDD=VDD B=n4706 VSS=VSS
XU3962 OAI31D2BWP7T $PINS ZN=n3421 A3=n3442 A2=n4654 A1=n4650 B=n4706 VDD=VDD
+ VSS=VSS
XU2636 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_1<4> ZN=n3882
XU2508 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4725 ZN=n2097 A1=n4830
XU2895 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2471 A1=n4532 A3=n2463 A2=n4643
XU2474 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2068 ZN=n2085 A3=n4657 A2=n2070
+ A1=n4537
XU2471 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2064 ZN=n2086 A3=n3861 A2=n2066
+ A1=n3813
XU2150 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1744 A1=SA_core_shift_wire<66>
+ ZN=n1748 A2=n1735
XU2143 AOI21D1BWP7T $PINS VSS=VSS A2=n1731 VDD=VDD A1=n1732 B=n1743 ZN=n1737
XU2393 AOI21D1BWP7T $PINS VSS=VSS A2=n1972 VDD=VDD A1=n1973 B=n1989 ZN=n1978
XU2388 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1979 A1=n4619 A3=n1971 A2=n4636
XU1966 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1575 ZN=n1592 A3=n3868 A2=n1577
+ A1=n3810
XU1963 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1571 ZN=n1593 A3=n3867 A2=n1573
+ A1=n3812
XU1938 MAOI222D1BWP7T $PINS ZN=n1534 C=n1531 B=n1532 VDD=VDD A=n1533 VSS=VSS
XU1674 MAOI222D1BWP7T $PINS ZN=n1266 C=n1263 B=n1264 VDD=VDD A=n1265 VSS=VSS
XU1665 AOI21D0BWP7T $PINS VSS=VSS A2=n1254 VDD=VDD A1=n2982 B=n1287 ZN=n1259
XU1575 MAOI222D1BWP7T $PINS ZN=n1168 C=n1165 B=n1166 VDD=VDD A=n1167 VSS=VSS
XU1522 AOI21D0BWP7T $PINS VSS=VSS A2=n1117 VDD=VDD A1=n1118 B=n1134 ZN=n1123
XU1514 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1124 A1=n4635 A3=n1116 A2=n4640
XU4564 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4718 ZN=n3740 A2=n4244
XU4459 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3659 ZN=n3720 A2=n4244
XU4533 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3701 ZN=n3710 A2=n4244
XU4515 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3689 ZN=n3700 A2=n4244
XU4717 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4371 A3=n4677 A2=n4772
+ A1=n4780
XU4480 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3677 A2=n4359
XU4718 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4218 B=n4707 A2=n3183 A1=n4772
XU4464 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4218 ZN=n3666 A1=n4359
XU4440 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4718 ZN=n3656 A2=n4717
XU4391 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3689 ZN=n3618 A2=n4717
XU4374 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4802 ZN=n3607 A2=n4717
XU4357 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3598 A2=n4717
XU4341 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n3664 ZN=n3588 A1=n4717
XU4287 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4710 ZN=n3557 A2=n4356
XU4270 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3689 ZN=n3547 A2=n4735
XU4253 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4421 ZN=n3537 A2=n4735
XU4721 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 A1=n3514 ZN=n4242 A2=n4462
XU4235 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3528 A2=n4242
XU4219 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4776 ZN=n3517 A1=n4735
XU4194 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4718 ZN=n3512 A2=n4721
XU4089 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3659 ZN=n3494 A2=n4721
XU4162 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4710 ZN=n3484 A2=n4721
XU4127 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4803 ZN=n3465 A2=n4721
XU4110 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3454 A2=n4721
XU4094 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4339 ZN=n3445 A1=n4721
XU4070 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4719 ZN=n3440 A2=n4804
XU3963 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3659 ZN=n3420 A2=n4424
XU4003 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4373 ZN=n3391 A2=n4757
XU3986 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3380 A2=n4722
XU3970 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4339 ZN=n3371 A1=n4757
XU3945 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4709 ZN=n3366 A2=n4716
XU3840 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4720 ZN=n3349 A2=n4716
XU4724 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 A1=n3183 ZN=n4247 A2=n4655
XU3914 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4247 ZN=n3340 A2=n4716
XU3897 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3689 ZN=n3330 A2=n4716
XU3879 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3678 ZN=n3321 A2=n4716
XU3861 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3310 A2=n4716
XU3845 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4738 ZN=n3299 A1=n4716
XU3709 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4720 ZN=n3278 A2=n4734
XU3789 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4345 ZN=n3269 A2=n4734
XU4725 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4374 A3=n4677 A2=n4772
+ A1=SA_ctrl_state_load_id<0>
XU3752 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4715 ZN=n3246 A2=n4734
XU3733 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4713 ZN=n3236 A2=n4734
XU3717 INR2XD2BWP7T $PINS VSS=VSS VDD=VDD B1=n4738 ZN=n3226 A1=n4734
XU3691 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3205 ZN=n3221 A2=n4709
XU3558 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4720 ZN=n3202 A2=n3205
XSA_core_pe_2_1_Aij_o_reg_0_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_1_N18 Q=SA_core_connect<56> VDD=VDD
XSA_core_pe_2_3_Bij_o_reg_0_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_3_N26 Q=SA_core_connect<184> VDD=VDD
XSA_core_pe_3_0_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<72>
+ D=SA_core_pe_3_0_N18 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_1_1_Bij_o_reg_1_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_1_1_N27 Q=SA_core_connect<129> VDD=VDD
XSA_core_pe_0_2_Bij_o_reg_1_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I3
+ D=SA_core_pe_0_2_N27 Q=SA_core_connect<145> VDD=VDD
XSA_A_3_shift_reg_reg_6__1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_3<1> D=n746
+ CP=clk_G2B4I7 VSS=VSS
XSA_core_pe_2_3_Bij_o_reg_1_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_2_3_N27 Q=SA_core_connect<185> VDD=VDD
XSA_core_pe_2_2_Bij_o_reg_1_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_2_2_N27 Q=SA_core_connect<161> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<120>
+ D=SA_core_pe_0_1_N26 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_0_2_Bij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<144>
+ D=SA_core_pe_0_2_N26 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_2_2_Bij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<160>
+ D=SA_core_pe_2_2_N26 CP=clk_G2B4I6 VSS=VSS
XSA_A_2_shift_reg_reg_6__1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<1> D=n690
+ CP=clk_G2B4I7 VSS=VSS
XSA_B_2_shift_reg_reg_6__1_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n914
+ Q=SA_col_2<1> VDD=VDD
XSA_core_pe_0_3_Cij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<0>
+ D=SA_core_pe_0_3_N10 CP=clk_G2B4I10 VSS=VSS
XSA_B_1_shift_reg_reg_6__0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n859
+ Q=SA_col_1<0> VDD=VDD
XSA_B_0_shift_reg_reg_6__0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n803
+ Q=SA_col_0<0> VDD=VDD
XSA_A_2_shift_reg_reg_6__0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I7 D=n691
+ Q=SA_row_2<0> VDD=VDD
XSA_core_pe_1_0_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<24>
+ D=SA_core_pe_1_0_N18 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_2_1_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<137>
+ D=SA_core_pe_2_1_N27 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_2_3_Cij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_2<0>
+ D=SA_core_pe_2_3_N10 CP=clk_G2B4I3 VSS=VSS
XSA_A_0_shift_reg_reg_6__0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_0<0> D=n1027
+ CP=clk_G2B4I8 VSS=VSS
XSA_B_3_shift_reg_reg_6__1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<1> D=n970
+ CP=clk_G2B4I9 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<1>
+ D=SA_core_pe_3_3_N11 CP=clk_G2B4I6 VSS=VSS
XSA_A_1_shift_reg_reg_6__0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_1<0> D=n635
+ CP=clk_G2B4I5 VSS=VSS
XSA_B_0_shift_reg_reg_6__1_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I1 D=n802
+ Q=SA_col_0<1> VDD=VDD
XSA_core_pe_0_3_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<169>
+ D=SA_core_pe_0_3_N27 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_0_0_Aij_o_reg_0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=SA_core_pe_0_0_N18 Q=SA_core_connect<0> VDD=VDD
XSA_core_pe_2_2_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<64>
+ D=SA_core_pe_2_2_N18 CP=clk_G2B4I2 VSS=VSS
XU1598 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4466 A3=n3442 A2=n4651
+ A1=n4653
XU1425 OA31D0BWP7T $PINS Z=n4460 B=n4706 A3=n4677 A2=n4772
+ A1=SA_ctrl_state_load_id<0> VDD=VDD VSS=VSS
XU3485 OAI21D2BWP7T $PINS B=n4706 A2=n4462 ZN=n4356 VDD=VDD A1=n3514 VSS=VSS
XU3383 OAI31D2BWP7T $PINS B=n4706 A3=n4462 ZN=n4359 A2=n4654 VDD=VDD A1=n4650
+ VSS=VSS
XU4458 OAI31D1BWP7T $PINS B=n4706 A3=n4462 ZN=n3721 A2=n4654 VDD=VDD A1=n4650
+ VSS=VSS
XU3501 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4490 A1=SA_ctrl_state_overall<0>
+ A3=n4510 A2=n4656
XU3690 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n3722 A3=n4655 A2=n4677
+ A1=SA_ctrl_state_load_id<0>
XU3153 AOI21D1BWP7T $PINS VSS=VSS A2=n2716 VDD=VDD A1=n2717 B=n4425 ZN=n2722
XU2674 MAOI222D1BWP7T $PINS ZN=n2248 C=n2245 B=n2246 VDD=VDD A=n2247 VSS=VSS
XU2908 MAOI222D1BWP7T $PINS ZN=n2475 C=n2469 B=n2470 VDD=VDD A=n2471 VSS=VSS
XU2169 MAOI222D1BWP7T $PINS ZN=n1757 C=n1754 B=n1755 VDD=VDD A=n1756 VSS=VSS
XU2151 MAOI222D2BWP7T $PINS ZN=n1747 C=n1736 B=n1737 VDD=VDD A=n1738 VSS=VSS
XU2401 MAOI222D1BWP7T $PINS ZN=n1983 C=n1977 B=n1978 VDD=VDD A=n1979 VSS=VSS
XU1684 AOI21D0BWP7T $PINS VSS=VSS A2=n1271 VDD=VDD A1=n3000 B=n1307 ZN=n1286
XU3409 MAOI222D1BWP7T $PINS ZN=n2991 C=n2988 B=n2989 VDD=VDD A=n2990 VSS=VSS
XU1651 MAOI222D1BWP7T $PINS ZN=n1256 C=n1245 B=n4443 VDD=VDD A=n1247 VSS=VSS
XU1774 MAOI222D1BWP7T $PINS ZN=n1375 C=n1363 B=n4444 VDD=VDD A=n1365 VSS=VSS
XU1609 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1221 ZN=n1225 A3=n3874 A2=n1223
+ A1=n4649
XU1461 ND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n4650 ZN=n3514 A2=n4653
XU3568 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n3664 B=n4707 A2=n3183 A1=n4772
XU4215 NR3D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n3516 A1=n4510 A3=n4462 A2=n3514
XU4090 NR4D4BWP7T $PINS VSS=VSS A4=n3442 VDD=VDD ZN=n3444 A3=n4510 A2=n4650
+ A1=n4653
XU3492 ND2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n3143 ZN=n3442
+ A2=SA_ctrl_state_load_AB
XU3964 NR4D3BWP7T $PINS VSS=VSS A4=n3442 VDD=VDD ZN=n3370 A3=n4654 A2=n4510
+ A1=n4650
XU3841 NR4D1BWP7T $PINS VSS=VSS A4=n3442 VDD=VDD ZN=n3298 A3=n4510 A2=n4651
+ A1=n4653
XU4999 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4454 A3=n4655 A2=n4677
+ A1=SA_ctrl_state_load_id<0>
XU3710 NR3D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n3225 A1=n4510 A3=n3442 A2=n3514
XU4997 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n4706 ZN=n4452 A3=n4655 A2=n4665
+ A1=SA_ctrl_state_load_id<1>
XU3557 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n4706 ZN=n3205 A2=n4249
XU3559 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n4510 ZN=n3148 A2=n3145
XU3519 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4665 ZN=n3183 A2=n4677
XU1463 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=SA_ctrl_state_overall<1> ZN=n3143
+ A2=n4522
XU3491 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3249 A1=n4772 A3=n3514 A2=n3113
XU1435 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=SA_ctrl_state_compute_out<0>
+ A1=SA_ctrl_state_compute_out<1> ZN=n3096 A3=ack
XU2981 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2560 ZN=n2577 A3=n3856 A2=n2562
+ A1=n3851
XU2978 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2556 ZN=n2578 A3=n3855 A2=n2558
+ A1=n4530
XU3304 MAOI222D1BWP7T $PINS ZN=n2866 C=n2863 B=n2864 VDD=VDD A=n2865 VSS=VSS
XU3285 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2853 A1=SA_core_shift_wire<10>
+ ZN=n2857 A2=n2844
XU3012 AN3D4BWP7T $PINS VSS=VSS A1=n4736 VDD=VDD A2=n4731 A3=ack Z=n2590
XSA_core_pe_0_0_Cij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<5>
+ D=SA_core_pe_0_0_N15 CP=clk_G2B4I4 VSS=VSS
XU4336 ND2D1P5BWP7T $PINS VSS=VSS A2=n4717 VDD=VDD A1=n3659 ZN=n3637
XSA_core_pe_2_0_Aij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<55>
+ D=SA_core_pe_2_0_N25 CP=clk_G2B4I5 VSS=VSS
XSA_B_1_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n852
+ Q=SA_col_1<7> VDD=VDD
XU4021 ND2D2BWP7T $PINS VSS=VSS A2=n4714 VDD=VDD A1=n3689 ZN=n3400
XSA_A_0_shift_reg_reg_6__2_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I8 D=n1025
+ Q=SA_row_0<2> VDD=VDD
XSA_core_pe_2_0_Cij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<55>
+ D=SA_core_pe_2_0_N17 CP=clk_G2B4I5 VSS=VSS
XU4836 OAI31D2BWP7T $PINS ZN=n4373 A3=n4677 A2=n4772 A1=n4780 B=n4706 VDD=VDD
+ VSS=VSS
XU3495 OAI211D1BWP7T $PINS VSS=VSS C=n3094 VDD=VDD A2=n3131 ZN=n3098 A1=n4770
+ B=n3095
XSA_core_pe_0_2_Aij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<18>
+ D=SA_core_pe_0_2_N20 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_2_2_Bij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<165>
+ D=SA_core_pe_2_2_N31 CP=clk_G2B4I6 VSS=VSS
XU4715 OAI31D1BWP7T $PINS B=n4706 A3=n4655 ZN=n4245 A2=n4677 VDD=VDD
+ A1=SA_ctrl_state_load_id<0> VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<7>
+ D=SA_core_pe_3_3_N17 CP=clk_G2B4I2 VSS=VSS
XSA_B_3_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<7> D=n964
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_2_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_2<7> D=n908
+ CP=clk_G2B4I4 VSS=VSS
XSA_core_pe_1_2_Bij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<159>
+ D=SA_core_pe_1_2_N33 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_1_1_Bij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<135>
+ D=SA_core_pe_1_1_N33 CP=clk_G2B4I5 VSS=VSS
XU4088 OAI31D1BWP7T $PINS B=n4706 A3=n3442 ZN=n3495 A2=n4653 VDD=VDD A1=n4650
+ VSS=VSS
XSA_core_pe_0_2_Bij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<150>
+ D=SA_core_pe_0_2_N32 CP=clk_G2B4I10 VSS=VSS
XSA_ctrl_state_compute_out_reg_0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I10
+ D=n4192 Q=SA_ctrl_state_compute_out<0> VDD=VDD
XSA_core_pe_2_3_Bij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<190>
+ D=SA_core_pe_2_3_N32 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_2_2_Bij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<163>
+ D=SA_core_pe_2_2_N29 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_2_3_Bij_o_reg_4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<188>
+ D=SA_core_pe_2_3_N30 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_2_3_Bij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<187>
+ D=SA_core_pe_2_3_N29 CP=clk_G2B4I2 VSS=VSS
XSA_ctrl_state_load_row_reg_1_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n4826
+ Q=SA_ctrl_state_load_row<1> VDD=VDD
XSA_A_2_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<7> D=n684
+ CP=clk_G2B4I5 VSS=VSS
XSA_A_1_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_1<7> D=n627
+ CP=clk_G2B4I5 VSS=VSS
XSA_A_3_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_3<7> D=n740
+ CP=clk_G2B4I7 VSS=VSS
XSA_ctrl_state_compute_out_reg_1_ DFQD1BWP7T $PINS VDD=VDD
+ Q=SA_ctrl_state_compute_out<1> D=n1091 CP=clk_G2B4I10 VSS=VSS
XSA_B_0_shift_reg_reg_6__7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<7> D=n796
+ CP=clk_G2B4I1 VSS=VSS
XSA_core_pe_1_2_Bij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<158>
+ D=SA_core_pe_1_2_N32 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_2_1_Aij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<62>
+ D=SA_core_pe_2_1_N24 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_2_0_Aij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<54>
+ D=SA_core_pe_2_0_N24 CP=clk_G2B4I5 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<6>
+ D=SA_core_pe_3_3_N16 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_2_3_Bij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<189>
+ D=SA_core_pe_2_3_N31 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_1_0_Cij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<30>
+ D=SA_core_pe_1_0_N16 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_2_0_Cij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<54>
+ D=SA_core_pe_2_0_N16 CP=clk_G2B4I6 VSS=VSS
XSA_ctrl_state_load_row_reg_0_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I5 D=n4167
+ Q=SA_ctrl_state_load_row<0> VDD=VDD
XSA_B_3_shift_reg_reg_6__6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<6> D=n965
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_1_shift_reg_reg_6__6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_1<6> D=n853
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_2_shift_reg_reg_6__6_ DFQD2BWP7T $PINS VDD=VDD Q=SA_col_2<6> D=n909
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_0_shift_reg_reg_6__6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<6> D=n797
+ CP=clk_G2B4I1 VSS=VSS
XSA_core_pe_1_1_Cij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<37>
+ D=SA_core_pe_1_1_N15 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_2_0_Cij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<53>
+ D=SA_core_pe_2_0_N15 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_1_1_Cij_o_reg_4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<36>
+ D=SA_core_pe_1_1_N14 CP=clk_G2B4I2 VSS=VSS
XSA_A_2_shift_reg_reg_6__6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<6> D=n685
+ CP=clk_G2B4I7 VSS=VSS
XSA_ctrl_state_load_id_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n1083
+ Q=SA_ctrl_state_load_id<2> VDD=VDD
XSA_ctrl_state_overall_reg_1_ DFQD1BWP7T $PINS VDD=VDD
+ Q=SA_ctrl_state_overall<1> D=n4168 CP=clk_G2B4I5 VSS=VSS
XSA_core_pe_2_0_Cij_o_reg_4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<52>
+ D=SA_core_pe_2_0_N14 CP=clk_G2B4I6 VSS=VSS
XSA_A_2_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<4> D=n687
+ CP=clk_G2B4I7 VSS=VSS
XSA_A_2_shift_reg_reg_6__5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<5> D=n686
+ CP=clk_G2B4I5 VSS=VSS
XSA_core_pe_2_2_Cij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<67>
+ D=SA_core_pe_2_2_N13 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_1_1_Cij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<35>
+ D=SA_core_pe_1_1_N13 CP=clk_G2B4I2 VSS=VSS
XSA_B_2_shift_reg_reg_6__5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_2<5> D=n910
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_2_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_2<4> D=n911
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_3_shift_reg_reg_6__5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<5> D=n966
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_3_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<4> D=n967
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_0_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<4> D=n799
+ CP=clk_G2B4I1 VSS=VSS
XSA_B_0_shift_reg_reg_6__5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<5> D=n798
+ CP=clk_G2B4I1 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<5>
+ D=SA_core_pe_3_3_N15 CP=clk_G2B4I2 VSS=VSS
XSA_B_1_shift_reg_reg_6__4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_1<4> D=n855
+ CP=clk_G2B4I4 VSS=VSS
XSA_ctrl_state_load_id_reg_0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n1081
+ Q=SA_ctrl_state_load_id<0> VDD=VDD
XSA_core_pe_0_1_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<121>
+ D=SA_core_pe_0_1_N27 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_1_2_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<153>
+ D=SA_core_pe_1_2_N27 CP=clk_G2B4I3 VSS=VSS
XSA_B_1_shift_reg_reg_6__5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_1<5> D=n854
+ CP=clk_G2B4I9 VSS=VSS
XSA_core_pe_2_2_Cij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<66>
+ D=SA_core_pe_2_2_N12 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<4>
+ D=n4815 CP=clk_G2B4I2 VSS=VSS
XSA_B_3_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<3> D=n968
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_2_shift_reg_reg_6__3_ DFQD2BWP7T $PINS VDD=VDD Q=SA_col_2<3> D=n912
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_1_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_1<3> D=n856
+ CP=clk_G2B4I9 VSS=VSS
XSA_core_pe_0_3_Cij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<2>
+ D=SA_core_pe_0_3_N12 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_3<3>
+ D=n4463 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_0_2_Bij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<146>
+ D=SA_core_pe_0_2_N28 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_2_3_Bij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<186>
+ D=SA_core_pe_2_3_N28 CP=clk_G2B4I2 VSS=VSS
XSA_core_pe_2_2_Bij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<162>
+ D=SA_core_pe_2_2_N28 CP=clk_G2B4I6 VSS=VSS
XSA_A_3_shift_reg_reg_6__0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_3<0> D=n747
+ CP=clk_G2B4I7 VSS=VSS
XSA_core_pe_2_0_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<113>
+ D=SA_core_pe_2_0_N27 CP=clk_G2B4I7 VSS=VSS
XSA_core_pe_2_0_Cij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<51>
+ D=SA_core_pe_2_0_N13 CP=clk_G2B4I6 VSS=VSS
XSA_B_3_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<2> D=n969
+ CP=clk_G2B4I9 VSS=VSS
XSA_B_2_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_2<2> D=n913
+ CP=clk_G2B4I4 VSS=VSS
XSA_core_pe_2_3_Cij_o_reg_2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_2<2>
+ D=SA_core_pe_2_3_N12 CP=clk_G2B4I3 VSS=VSS
XSA_A_2_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<2> D=n689
+ CP=clk_G2B4I5 VSS=VSS
XSA_A_1_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_1<2> D=n633
+ CP=clk_G2B4I5 VSS=VSS
XSA_A_1_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_1<3> D=n632
+ CP=clk_G2B4I5 VSS=VSS
XSA_A_2_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_2<3> D=n688
+ CP=clk_G2B4I7 VSS=VSS
XSA_B_0_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<2> D=n801
+ CP=clk_G2B4I1 VSS=VSS
XSA_A_3_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_3<2> D=n745
+ CP=clk_G2B4I7 VSS=VSS
XSA_A_3_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_row_3<3> D=n744
+ CP=clk_G2B4I7 VSS=VSS
XSA_B_1_shift_reg_reg_6__2_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_1<2> D=n857
+ CP=clk_G2B4I4 VSS=VSS
XSA_B_0_shift_reg_reg_6__3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_0<3> D=n800
+ CP=clk_G2B4I1 VSS=VSS
Xicc_place1584 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4639 I=SA_row_0<0>
Xicc_place1624 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<80> ZN=n4679
Xicc_place1573 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<185> ZN=n4628
Xicc_place1571 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4821 ZN=n4626
Xicc_place1539 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<136> Z=n4594
Xicc_place1515 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<89> Z=n4570
Xicc_place1627 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4682 I=SA_col_2<0>
Xicc_place1586 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4641 I=SA_col_3<1>
Xicc_place1524 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4578 ZN=n4579
Xicc_place1541 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<128> Z=n4596
Xicc_place1511 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<90> Z=n4566
Xicc_place1546 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<152> Z=n4601
Xicc_place1561 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<42> Z=n4616
Xicc_place1517 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<81> Z=n4572
Xicc_place1492 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<58> Z=n4547
Xicc_place1513 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<82> Z=n4568
Xicc_place1494 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<57> Z=n4549
Xicc_place1590 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4645
+ I=SA_core_connect<169>
Xicc_place1523 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<8> Z=n4578
Xicc_place1611 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<121> ZN=n4666
Xicc_place1486 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4780
+ I=SA_ctrl_state_load_id<0>
Xicc_place1503 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4776 I=n3664
XU2020 MAOI222D2BWP7T $PINS ZN=n4197 VDD=VDD VSS=VSS A=n1999 C=n1997 B=n1998
XU1997 MAOI222D1BWP7T $PINS ZN=n4193 VDD=VDD VSS=VSS A=n1144 C=n1142 B=n1143
XU1970 MAOI222D2BWP7T $PINS ZN=n4180 VDD=VDD VSS=VSS A=n2491 C=n2489 B=n2490
XU1839 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n3112 A1=n4655 ZN=n3172 A3=n3143
XU1804 ND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n4706 ZN=n3689 A2=n3172
XU1720 MOAI22D0BWP7T $PINS A2=n3086 A1=n2983 ZN=n4463 B1=n3084 VSS=VSS
+ B2=SA_core_shift_wire<91> VDD=VDD
XU1550 INR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=SA_row_1<7> ZN=SA_core_pe_1_0_N25
+ B1=n4726
XU1436 AOI21D2BWP7T $PINS VSS=VSS A2=n4656 VDD=VDD A1=n4703 B=n4705 ZN=n3126
XU1430 AO211D0BWP7T $PINS Z=n1081 C=n4705 B=n3121 A2=n3126 VDD=VDD A1=n4780
+ VSS=VSS
XSA_core_pe_3_2_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<88>
+ D=SA_core_pe_3_2_N18 CP=clk_G2B4I6 VSS=VSS
XU4809 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4244 I=n3721
XU2003 INR2XD4BWP7T $PINS VSS=VSS A1=n4816 VDD=VDD B1=n4730 ZN=n1606
XU4497 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n4371 ZN=n3688 A2=n4267
XU3771 AOI21D1BWP7T $PINS VSS=VSS A1=n3249 VDD=VDD B=n4707 ZN=n3260 A2=n4711
XU4969 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4424 I=n4352
XSA_core_pe_0_3_Cij_o_reg_7_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<7>
+ D=SA_core_pe_0_3_N17 CP=clk_G2B4I10 VSS=VSS
XU3479 AOI21D0BWP7T $PINS VSS=VSS A1=n4656 VDD=VDD B=n4510 ZN=n3137 A2=n4522
XSA_ctrl_state_load_id_reg_1_ DFQD2BWP7T $PINS VDD=VDD
+ Q=SA_ctrl_state_load_id<1> D=n1080 CP=clk_G2B4I4 VSS=VSS
XSA_core_pe_0_3_Cij_o_reg_6_ DFQD2BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<6>
+ D=SA_core_pe_0_3_N16 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_0_3_Cij_o_reg_5_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<5>
+ D=SA_core_pe_0_3_N15 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_0_3_Cij_o_reg_4_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<4>
+ D=SA_core_pe_0_3_N14 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_2_ DFQD1BWP7T $PINS VSS=VSS CP=clk_G2B4I6
+ D=SA_core_pe_3_3_N12 Q=SA_core_output_row_3<2> VDD=VDD
XSA_core_pe_0_3_Cij_o_reg_3_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<3>
+ D=SA_core_pe_0_3_N13 CP=clk_G2B4I10 VSS=VSS
XU4970 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4425 I=n2728
XSA_core_pe_3_1_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<80>
+ D=SA_core_pe_3_1_N18 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_2_0_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<48>
+ D=SA_core_pe_2_0_N18 CP=clk_G2B4I6 VSS=VSS
XSA_core_pe_1_1_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<32>
+ D=SA_core_pe_1_1_N18 CP=clk_G2B4I3 VSS=VSS
XSA_B_2_shift_reg_reg_6__0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_2<0> D=n915
+ CP=clk_G2B4I4 VSS=VSS
XSA_core_pe_1_3_Bij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<176>
+ D=SA_core_pe_1_3_N26 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_3_3_Cij_o_reg_0_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I2
+ D=SA_core_pe_3_3_N10 Q=SA_core_output_row_3<0> VDD=VDD
XSA_B_3_shift_reg_reg_6__0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_col_3<0> D=n971
+ CP=clk_G2B4I9 VSS=VSS
XSA_core_pe_1_0_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<105>
+ D=SA_core_pe_1_0_N27 CP=clk_G2B4I5 VSS=VSS
XSA_core_pe_0_0_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<97>
+ D=SA_core_pe_0_0_N27 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_1_3_Bij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<177>
+ D=SA_core_pe_1_3_N27 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_1_2_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<40>
+ D=SA_core_pe_1_2_N18 CP=clk_G2B4I3 VSS=VSS
XSA_core_pe_0_2_Aij_o_reg_0_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_connect<16>
+ D=SA_core_pe_0_2_N18 CP=clk_G2B4I10 VSS=VSS
XSA_core_pe_0_3_Cij_o_reg_1_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_output_row_0<1>
+ D=SA_core_pe_0_3_N11 CP=clk_G2B4I10 VSS=VSS
XSA_B_1_shift_reg_reg_6__1_ DFQD2BWP7T $PINS VSS=VSS CP=clk_G2B4I4 D=n858
+ Q=SA_col_1<1> VDD=VDD
XU4214 ND2D1P5BWP7T $PINS VSS=VSS A2=n4735 VDD=VDD A1=n3659 ZN=n3566
XSA_core_pe_1_1_Cij_o_reg_6_ DFQD1BWP7T $PINS VDD=VDD Q=SA_core_shift_wire<38>
+ D=SA_core_pe_1_1_N16 CP=clk_G2B4I10 VSS=VSS
XU3031 AOI21D1BWP7T $PINS VSS=VSS A2=n3841 VDD=VDD A1=n1390 B=n4771 ZN=n4252
XU3014 MAOI222D1BWP7T $PINS ZN=n4170 C=n1635 B=n1633 VDD=VDD A=n1634 VSS=VSS
XU3008 MAOI222D1BWP7T $PINS ZN=n4175 C=n2126 B=n2124 VDD=VDD A=n2125 VSS=VSS
XU2985 AOI21D1BWP7T $PINS A2=n4522 A1=SA_ctrl_state_overall<1> ZN=n3658 VDD=VDD
+ B=n4510 VSS=VSS
XU2974 OA31D0BWP7T $PINS Z=n4475 B=n4706 A3=n4655 A2=n4665
+ A1=SA_ctrl_state_load_id<1> VDD=VDD VSS=VSS
XU2954 OAI31D2BWP7T $PINS ZN=n4352 A3=n4654 A2=n4650 A1=n3442 B=n4706 VDD=VDD
+ VSS=VSS
XU2928 OAI21D1BWP7T $PINS B=n4706 A2=n4655 ZN=n4344 VDD=VDD A1=n3183 VSS=VSS
XU2901 OAI31D1BWP7T $PINS B=n4706 A3=n4654 ZN=n4275 A2=n4650 VDD=VDD A1=n3442
+ VSS=VSS
XU2892 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n4462 A3=n4510 A2=n4651 A1=n4653
+ Z=n4474
XU2842 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n4462 A3=n4654 A2=n4510 A1=n4650
+ Z=n4473
XU2716 OA21D1BWP7T $PINS Z=n4339 B=n4706 A1=n4772 VDD=VDD A2=n3183 VSS=VSS
XU2597 AO211D0BWP7T $PINS Z=n4472 C=n4806 B=n3111 A2=n3183 VDD=VDD A1=n4650
+ VSS=VSS
XU2591 INVD0BWP7T $PINS ZN=n3119 VSS=VSS VDD=VDD I=n4472
XU2488 OR2D4BWP7T $PINS VSS=VSS VDD=VDD Z=n4470 A2=n4816 A1=n4730
XU2478 OA31D0BWP7T $PINS Z=n4469 B=n4706 A3=n4677 A2=n4772
+ A1=SA_ctrl_state_load_id<0> VDD=VDD VSS=VSS
XU2467 INVD1BWP7T $PINS ZN=n3678 VSS=VSS VDD=VDD I=n4469
XU2377 INVD2P5BWP7T $PINS VSS=VSS VDD=VDD I=n4475 ZN=n3659
XU2217 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2469 A1=n4536 A2=n4532
XU2092 MAOI222D2BWP7T $PINS ZN=n4209 VDD=VDD VSS=VSS A=n2723 C=n2721 B=n2722
XU2086 MAOI222D1BWP7T $PINS ZN=n4235 VDD=VDD VSS=VSS A=n2107 C=n2105 B=n4447
Xicc_clock1446 INVD0BWP7T $PINS ZN=n4799 VSS=VSS VDD=VDD I=n2742
Xicc_clock1447 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4800 I=n3371
Xicc_clock1448 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4801 I=SA_core_pe_2_0_N11
Xicc_clock1449 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4802 I=n4272
Xicc_clock1450 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4803 I=n4271
Xicc_clock1451 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4804 I=n4352
XCTSCKND12BWP7T_G2B1I1 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I1
+ I=clk_G2B3I2
XCTSCKND10BWP7T_G2B1I3 CKND10BWP7T $PINS VSS=VSS VDD=VDD I=clk_G2B3I1
+ ZN=clk_G2B4I3
XCTSCKND12BWP7T_G2B1I5 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I5
+ I=clk_G2B3I2
XCTSCKND10BWP7T_G2B1I7 CKND10BWP7T $PINS VSS=VSS VDD=VDD I=clk_G2B3I2
+ ZN=clk_G2B4I7
XCTSCKND12BWP7T_G2B1I9 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I9
+ I=clk_G2B3I1
XCTSCKND12BWP7T_G2B4I1 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B1I1 I=clk
XCTSCKND10BWP7T_G2B2I2 INVD12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B3I2
+ I=clk_G2B2I1
XCTSCKND12BWP7T_G2B1I8 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I8
+ I=clk_G2B3I2
XCTSCKND12BWP7T_G2B1I6 INVD12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I6
+ I=clk_G2B3I2
XCTSCKND8BWP7T_G2B1I2 INVD10BWP7T $PINS VSS=VSS I=clk_G2B3I2 VDD=VDD
+ ZN=clk_G2B4I2
XCTSCKND12BWP7T_G2B1I4 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B4I4
+ I=clk_G2B3I1
XCTSCKND10BWP7T_G2B1I10 INVD10BWP7T $PINS VSS=VSS I=clk_G2B3I1 VDD=VDD
+ ZN=clk_G2B4I10
XCTSCKND8BWP7T_G2B2I1 INVD10BWP7T $PINS VSS=VSS I=clk_G2B2I1 VDD=VDD
+ ZN=clk_G2B3I1
XCTSCKND3BWP7T_G2B3I1 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G2B2I1
+ I=clk_G2B1I1
Xicc_place1519 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4777 I=n3495
Xicc_place1528 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4778 I=n1123
Xicc_place1525 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<127> Z=n4580
Xicc_place1711 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4770 I=n3096
Xicc_place1649 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3137 Z=n4704
Xicc_place1548 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<175> Z=n4603
Xicc_place1652 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4706 ZN=n4707
Xicc_place1596 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4650 ZN=n4651
Xicc_place1478 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<7> Z=n4533
Xicc_place1456 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<7> Z=n4511
Xicc_place1651 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4706 I=n3658
Xicc_place1713 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4772
+ I=SA_ctrl_state_load_id<2>
Xicc_place1622 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n4677
+ I=SA_ctrl_state_load_id<1>
Xicc_place1597 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4652 I=SA_col_0<7>
Xicc_place1565 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<174> Z=n4620
Xicc_place1556 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<38> Z=n4611
Xicc_place1497 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<62>
+ Z=n4552
Xicc_place1549 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<182> Z=n4604
Xicc_place1479 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<6> Z=n4534
Xicc_place1527 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<126> Z=n4582
Xicc_place1526 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<134> Z=n4581
Xicc_place1499 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<86> Z=n4554
Xicc_place1457 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<6> Z=n4512
Xicc_place1600 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_ctrl_state_load_id<2>
+ ZN=n4655
Xicc_place1500 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<93> Z=n4555
Xicc_place1483 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<45>
+ Z=n4538
Xicc_place1530 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<125> ZN=n4585
Xicc_place1485 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<69> Z=n4540
Xicc_place1529 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<133> ZN=n4584
Xicc_place1468 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_shift_wire<93>
+ ZN=n4523
Xicc_place1543 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<21>
+ Z=n4598
Xicc_place1467 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_ctrl_state_overall<0>
+ ZN=n4522
Xicc_place1469 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_shift_wire<77>
+ ZN=n4524
Xicc_place1609 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=SA_col_0<4> ZN=n4664
Xicc_place1520 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4840 ZN=n4575
Xicc_place1532 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<132> ZN=n4587
Xicc_place1462 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4516 ZN=n4517
Xicc_place1491 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4545 ZN=n4546
Xicc_place1602 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_row_2<4> ZN=n4657
Xicc_place1490 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<52> Z=n4545
Xicc_place1603 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4658 I=SA_col_2<5>
Xicc_place1488 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<60> Z=n4543
Xicc_place1471 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<4> Z=n4526
Xicc_place1605 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4660 I=SA_col_2<4>
Xicc_place1498 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<60>
+ Z=n4553
Xicc_place1461 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<4> Z=n4516
Xicc_place1459 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<5> Z=n4514
Xicc_place1508 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4562 ZN=n4563
Xicc_place1510 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4564 ZN=n4565
Xicc_place1466 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4520 ZN=n4521
Xicc_place1482 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<107> ZN=n4537
Xicc_place1475 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<98> ZN=n4530
Xicc_place1477 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4531 ZN=n4532
Xicc_place1581 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_2<0> ZN=n4636
Xicc_place1594 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4649 I=SA_row_0<2>
Xicc_place1632 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_connect<97> ZN=n4687
Xicc_place1564 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4618 ZN=n4619
Xicc_place1568 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4622 ZN=n4623
Xicc_place1620 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4674 ZN=n4675
Xicc_place1588 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_1<0> ZN=n4643
Xicc_place1465 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<1> Z=n4520
Xicc_place1463 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_row_0<3> Z=n4518
Xicc_place1551 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4605 ZN=n4606
Xicc_place1521 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<19> Z=n4576
Xicc_place1545 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4599 ZN=n4600
Xicc_place1536 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4590 ZN=n4591
Xicc_place1619 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4674 I=SA_col_0<2>
Xicc_place1476 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<96> Z=n4531
Xicc_place1553 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4607 ZN=n4608
Xicc_place1533 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<139> Z=n4588
Xicc_place1613 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4668 I=SA_row_3<0>
Xicc_place1567 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<51> Z=n4622
Xicc_place1563 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<104> Z=n4618
Xicc_place1538 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4592 ZN=n4593
Xicc_place1509 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<75> Z=n4564
Xicc_place1507 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<83> Z=n4562
Xicc_place1505 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<91> Z=n4560
Xicc_place1585 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4639 ZN=n4640
Xicc_place1559 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_connect<43> Z=n4614
Xicc_place1618 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n4672 ZN=n4673
Xicc_place1470 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=SA_core_shift_wire<89>
+ ZN=n4525
Xicc_place1555 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4609 ZN=n4610
Xicc_place1493 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4547 ZN=n4548
Xicc_place1458 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4513 I=n4512
Xicc_place1460 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4515 I=n4514
Xicc_place1472 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4527 I=n4526
Xicc_place1487 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4542 I=n4846
Xicc_place1489 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4544 I=n4543
Xicc_place1502 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4557 I=n4832
Xicc_place1504 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4559 I=SA_core_connect<76>
Xicc_place1506 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4561 I=n4560
Xicc_place1534 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4589 I=n4588
Xicc_place1558 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4613 I=n4837
Xicc_place1601 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n4656
+ I=SA_ctrl_state_overall<1>
Xicc_place1604 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4659 I=n4658
Xicc_place1606 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4661 I=n4660
Xicc_place1607 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4662 I=SA_col_3<5>
Xicc_place1610 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4665
+ I=SA_ctrl_state_load_id<0>
Xicc_place1614 CKND2BWP7T $PINS VSS=VSS I=n4668 VDD=VDD ZN=n4669
Xicc_place1648 INVD0BWP7T $PINS ZN=n4703 VSS=VSS VDD=VDD I=n3249
Xicc_place1654 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4245 Z=n4709
Xicc_place1656 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4711 I=n3442
Xicc_place1657 INVD0BWP7T $PINS ZN=n4712 VSS=VSS VDD=VDD I=n3092
Xicc_place1660 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4374 Z=n4715
Xicc_place1667 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4722 I=n4275
Xicc_place1670 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4725 I=n4476
Xicc_place1675 BUFFD12BWP7T $PINS VDD=VDD VSS=VSS I=n4725 Z=n4730
Xicc_place1685 INVD0BWP7T $PINS ZN=n4740 VSS=VSS VDD=VDD I=n3098
Xicc_place1686 INVD0BWP7T $PINS ZN=n4741 VSS=VSS VDD=VDD I=n3128
Xicc_place1689 INVD0BWP7T $PINS ZN=n4744 VSS=VSS VDD=VDD I=n4175
Xicc_place1695 INVD0BWP7T $PINS ZN=n4750 VSS=VSS VDD=VDD I=n1877
Xicc_place1696 INVD0BWP7T $PINS ZN=n4751 VSS=VSS VDD=VDD I=n2369
Xicc_place1697 INVD0BWP7T $PINS ZN=n4752 VSS=VSS VDD=VDD I=n2620
Xicc_place1698 INVD0BWP7T $PINS ZN=n4753 VSS=VSS VDD=VDD I=n1757
Xicc_place1699 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4754 I=n2866
Xicc_place1700 INVD0BWP7T $PINS ZN=n4755 VSS=VSS VDD=VDD I=n1168
Xicc_place1639 AO21D0BWP7T $PINS Z=n4756 B=n2852 A1=n2841 VDD=VDD A2=n2840
+ VSS=VSS
Xicc_place1672 OAI31D2BWP7T $PINS ZN=n4757 A3=n3442 A2=n4654 A1=n4650 B=n4706
+ VDD=VDD VSS=VSS
Xicc_place1702 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4761 I=shift_out<3>
Xicc_place1706 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3298 Z=n4765
Xicc_place1707 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4766 I=n3370
Xicc_place1710 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4769 A1=n3091
+ A3=SA_ctrl_state_compute_out<1> A2=n4708
Xicc_place1712 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4771 I=n1428
Xicc_place1684 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4739 I=n3260
Xicc_place1658 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n4713 I=n3667
Xicc_place1446 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4501 I=shift_in<7>
Xicc_place1447 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4502 I=shift_in<6>
Xicc_place1448 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4503 I=shift_in<5>
Xicc_place1455 INVD8BWP7T $PINS VSS=VSS VDD=VDD I=n4509 ZN=n4510
Xicc_place1451 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4506 I=shift_in<2>
Xicc_place1452 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4507 I=shift_in<1>
Xicc_place1453 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4508 I=shift_in<0>
Xicc_place1454 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4509 I=rstn
Xicc_place1692 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n4747 I=n4470
Xicc_place1669 CKND2BWP7T $PINS VSS=VSS I=n4473 VDD=VDD ZN=n4724
Xicc_place1683 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4340 Z=n4738
Xicc_place1644 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4699 I=n4693
Xicc_place1694 INVD2P5BWP7T $PINS VSS=VSS VDD=VDD I=n3086 ZN=n4749
Xicc_place1642 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4697 I=n4693
Xicc_place1641 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4696 I=n4693
Xicc_place1668 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4474 ZN=n4723
Xicc_place1646 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n4701 I=n4693
Xicc_place1496 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=SA_core_shift_wire<63>
+ Z=n4551
Xicc_place1661 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4716 I=n4466
Xicc_place1665 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4452 Z=n4720
Xicc_place1655 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4710 I=n4344
Xicc_place1680 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4735 I=n3567
Xicc_place1679 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4734 I=n3279
Xicc_place1662 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4717 I=n4805
Xicc_place1664 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4454 Z=n4719
Xicc_place1659 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3421 Z=n4714
Xicc_place1650 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4704 ZN=n4705
Xicc_place1638 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4693 I=n4490
Xu_pad_vdd1_0 PVDD1CDG $PINS VDD=VDD
Xu_pad_vss3_0 PVSS3CDG $PINS VSS=VSS
Xu_pad_vdd2_0 PVDD2CDG $PINS
Xu_pad_vdd1_1 PVDD1CDG $PINS VDD=VDD
Xu_pad_vss3_1 PVSS3CDG $PINS VSS=VSS
Xu_pad_vdd2_1 PVDD2CDG $PINS
Xu_pad_vdd1_2 PVDD1CDG $PINS VDD=VDD
Xu_pad_vss3_2 PVSS3CDG $PINS VSS=VSS
Xu_pad_vdd2_2 PVDD2CDG $PINS
Xu_pad_vdd1_3 PVDD1CDG $PINS VDD=VDD
Xu_pad_vss3_3 PVSS3CDG $PINS VSS=VSS
Xu_pad_vdd2_3 PVDD2CDG $PINS
Xxofiller_DCAP64BWP7T_1 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_2 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_3 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_4 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_5 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_6 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_7 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_9 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_10 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_11 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_12 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_13 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_15 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_16 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_17 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_19 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_20 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_21 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_22 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_23 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_24 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_25 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_26 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_27 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_28 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_29 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_31 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_32 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_33 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_37 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_38 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_39 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_40 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_41 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_43 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_47 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_48 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_49 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_50 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_51 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_53 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_54 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_55 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_56 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_57 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_58 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_59 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_60 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_61 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_62 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_63 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_65 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_66 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_68 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_70 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_71 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_72 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_74 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_77 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_78 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_80 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_81 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_82 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_83 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_84 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_85 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_88 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_89 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_90 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_91 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_92 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_94 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_95 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_96 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_97 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_98 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_99 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_100 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_101 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_102 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_103 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_104 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_105 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_107 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_112 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_113 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_115 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_116 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_117 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_118 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_119 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_120 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_122 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_123 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_124 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_126 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_127 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_130 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_131 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_133 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_134 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_135 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_137 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_138 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_139 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_140 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_141 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_142 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_143 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_145 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_146 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_148 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_151 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_152 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_153 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_154 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_155 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_156 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_157 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_158 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_159 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_160 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_162 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_164 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_165 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_166 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_167 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_168 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_169 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_170 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_171 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_172 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_173 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_174 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_175 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_176 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_177 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_178 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_179 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_180 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_181 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_182 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_183 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_184 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_185 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_186 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_187 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_188 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_190 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_193 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_194 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_195 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_196 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_197 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_200 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_201 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_202 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_203 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_204 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_205 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_206 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_207 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_208 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_209 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_210 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_211 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_212 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_216 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_217 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_218 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_219 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_220 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_221 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_222 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_223 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_224 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_226 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_227 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_230 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_231 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_232 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_233 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_234 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_235 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_236 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_237 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_239 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_241 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_242 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_243 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_246 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_248 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_249 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_250 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_251 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_252 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_253 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_254 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_255 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_257 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_259 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_260 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_261 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_262 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_266 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_267 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_268 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_270 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_272 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_273 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_274 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_275 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_278 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_279 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_281 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_282 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_285 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_286 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_287 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_288 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_290 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_291 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_292 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_293 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_295 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_296 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_297 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_300 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_301 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_302 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_303 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_304 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_306 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_308 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_309 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_311 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_312 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_313 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_314 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_315 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_317 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_320 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_321 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_322 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_324 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_327 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_328 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_329 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_330 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_332 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_333 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_334 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_338 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_339 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_341 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_345 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_346 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_347 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_348 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_349 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_350 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_351 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_352 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_353 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_354 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_355 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_356 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_357 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_359 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_360 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP64BWP7T_361 DCAP64BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_2 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_3 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_5 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_6 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_7 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_9 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_10 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_11 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_13 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_14 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_15 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_19 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_32 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_33 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_34 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_36 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_37 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_38 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_39 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_42 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_43 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_44 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_46 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_47 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_49 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_50 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_51 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_52 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_53 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_58 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_59 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_63 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_64 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_65 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_66 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_67 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_68 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_71 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_72 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_73 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_74 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_75 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_77 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_78 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_80 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_85 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_86 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_87 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_88 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_89 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_90 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_92 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_94 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_95 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_96 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_99 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_100 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_101 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_102 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_103 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_105 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_106 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_107 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_108 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_110 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_112 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_113 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_116 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_118 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_120 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_121 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_122 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_123 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_124 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_127 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_128 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_129 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_131 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_132 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_133 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_134 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_136 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_138 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_139 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_142 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_143 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_145 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_146 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_147 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_150 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_153 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_154 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_155 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_156 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_157 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_158 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_159 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_161 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_162 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_163 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_166 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_167 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_168 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_169 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_171 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_172 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_173 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_175 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_176 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_177 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_178 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_179 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_182 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_183 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_185 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_188 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_189 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_191 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_192 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_193 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_195 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_198 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_199 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_200 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_202 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_203 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_204 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_206 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_207 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_210 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_211 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_212 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_213 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_215 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_217 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_218 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_219 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_220 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_221 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_222 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_223 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_227 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_229 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_230 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_231 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_232 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_233 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_234 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_235 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_236 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_237 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_238 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_239 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_240 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_244 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_245 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_246 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_248 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_250 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_251 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_254 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_256 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_257 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_261 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_262 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_265 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_266 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_267 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_268 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_269 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_270 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_271 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_272 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_276 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_277 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_278 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_280 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_281 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_282 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_285 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_286 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_287 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_289 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_291 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_294 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_295 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_297 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_298 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_299 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_300 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_301 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_302 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_307 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_309 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_310 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_311 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_312 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_315 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_316 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_317 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_318 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_319 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_321 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_322 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_323 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_325 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_327 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_328 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_330 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_331 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_332 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_335 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_337 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_339 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_341 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_342 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_343 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_344 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_347 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_348 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_351 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_352 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_354 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_355 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_356 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_357 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_358 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_360 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_362 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_363 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_364 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_365 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_366 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_367 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_368 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_370 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_371 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_373 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_374 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_376 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_377 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_378 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_379 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_380 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_381 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_382 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_384 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_386 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_389 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_390 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_391 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_393 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_395 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_396 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_397 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_398 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_399 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_400 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_402 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_404 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_405 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_410 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_412 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_413 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_415 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_416 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_419 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_420 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_421 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_422 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_425 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_426 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_427 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_429 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_430 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_433 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_435 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_437 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_438 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_439 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_440 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_441 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_443 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_445 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_446 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_448 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_449 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_451 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_454 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_455 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_456 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_458 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_459 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_461 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_462 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_465 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_466 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_469 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_470 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_471 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_473 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_475 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_476 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_477 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_478 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_479 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_480 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_484 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_485 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_488 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_490 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_491 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_492 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_494 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_495 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_500 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_501 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_504 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_506 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_508 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_511 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_512 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_513 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_514 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_515 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_516 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_517 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_518 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_519 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_520 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_522 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_523 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_525 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_526 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_527 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_531 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_533 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_536 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_538 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_539 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_540 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_542 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_543 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_544 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_545 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_546 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_547 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_548 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_550 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_551 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_555 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_556 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_559 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_560 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_561 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_563 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_564 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_565 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_567 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_568 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_569 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_571 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_572 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_573 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_574 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_576 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_577 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_578 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_579 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_580 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_581 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_582 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_583 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_587 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_588 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_589 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_590 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_591 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_592 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_593 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_594 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_595 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_596 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_597 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_598 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_599 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_600 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_606 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_608 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_613 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_615 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_616 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_618 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_619 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_621 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_623 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_624 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_625 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_627 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_628 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_629 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_632 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_633 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_634 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_636 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_637 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_639 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_642 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_643 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_644 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_645 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_646 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_648 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_649 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_650 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_653 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_654 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_656 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_659 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_661 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_663 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_664 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_665 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_666 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_667 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_668 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_669 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_670 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_672 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_674 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_675 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_676 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_677 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_680 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_681 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_682 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_684 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_686 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_687 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_689 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_690 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_691 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_692 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_694 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_695 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_696 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_697 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_699 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_701 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_702 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_705 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_707 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_708 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_709 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_710 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_711 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_712 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_715 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_716 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_717 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_720 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_721 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_722 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_723 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_724 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_725 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_726 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_727 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_728 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_730 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_731 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_734 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_736 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_737 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_739 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_741 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_743 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_744 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_745 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_746 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_747 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_749 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_751 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_752 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_753 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_754 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_755 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_758 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_759 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_760 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_761 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_762 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_765 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_766 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_768 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_769 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_772 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_773 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_774 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_776 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_777 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_778 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_779 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_781 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_783 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_786 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_788 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_789 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_790 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_791 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_792 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_796 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_797 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_799 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_800 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_801 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_802 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_803 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_804 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_805 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_808 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_810 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_811 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_813 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_816 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_817 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_818 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_820 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_822 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_823 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_824 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_825 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_826 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_830 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_831 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_832 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_835 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_837 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_838 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_840 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_842 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_843 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_844 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_845 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_846 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_848 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_849 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_852 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_853 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_855 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_856 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_858 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_859 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_862 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_863 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_864 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_866 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_867 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_868 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_870 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_871 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_872 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_873 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_874 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_875 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_876 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_877 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_878 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_879 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_882 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_883 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_884 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_885 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_886 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_887 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_888 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_889 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_890 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_891 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_894 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_895 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_896 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_898 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_901 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_903 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_904 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_905 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_906 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_907 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_908 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_909 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_911 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_913 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_914 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_916 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_918 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_921 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_923 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_926 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_927 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_930 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_931 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_932 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_934 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_937 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_938 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_939 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_940 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_2 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_5 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_6 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_7 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_9 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_10 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_14 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_15 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_16 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_18 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_19 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_21 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_22 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_23 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_24 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_25 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_27 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_28 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_29 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_30 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_34 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_36 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_37 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_39 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_40 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_41 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_42 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_44 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_46 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_48 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_49 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_50 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_53 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_54 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_56 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_57 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_58 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_59 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_60 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_62 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_63 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_65 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_67 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_68 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_69 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_71 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_73 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_74 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_75 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_76 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_77 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_78 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_79 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_80 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_81 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_82 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_83 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_84 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_86 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_87 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_88 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_90 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_92 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_93 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_94 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_95 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_96 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_98 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_99 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_100 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_101 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_105 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_106 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_108 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_109 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_110 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_111 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_112 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_113 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_115 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_116 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_117 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_118 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_119 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_121 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_126 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_127 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_128 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_130 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_131 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_133 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_134 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_135 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_136 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_137 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_138 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_139 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_141 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_143 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_145 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_146 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_148 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_149 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_152 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_153 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_154 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_155 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_156 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_159 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_160 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_161 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_162 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_165 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_166 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_167 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_170 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_171 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_172 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_173 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_174 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_175 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_176 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_177 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_178 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_179 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_180 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_181 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_182 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_183 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_185 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_186 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_188 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_189 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_190 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_191 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_192 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_195 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_197 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_198 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_199 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_200 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_202 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_203 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_204 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_206 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_207 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_209 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_210 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_211 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_212 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_213 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_214 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_216 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_217 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_218 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_221 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_222 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_223 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_224 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_225 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_226 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_227 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_228 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_229 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_231 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_232 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_233 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_234 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_235 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_236 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_237 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_238 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_241 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_242 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_243 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_244 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_245 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_247 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_248 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_249 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_250 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_251 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_254 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_255 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_257 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_259 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_260 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_261 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_262 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_264 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_265 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_266 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_267 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_269 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_270 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_271 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_272 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_273 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_274 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_275 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_276 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_277 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_278 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_279 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_280 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_281 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_282 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_283 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_284 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_286 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_288 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_290 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_291 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_292 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_294 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_295 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_296 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_297 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_298 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_300 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_301 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_302 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_303 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_304 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_307 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_308 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_309 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_311 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_313 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_314 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_316 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_317 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_318 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_319 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_322 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_323 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_325 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_326 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_327 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_328 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_329 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_331 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_333 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_335 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_336 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_338 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_340 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_342 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_343 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_344 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_346 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_347 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_351 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_352 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_353 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_354 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_355 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_356 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_357 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_359 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_360 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_361 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_362 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_363 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_364 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_365 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_366 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_367 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_368 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_369 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_370 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_371 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_373 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_374 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_376 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_380 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_381 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_382 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_383 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_384 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_385 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_386 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_387 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_388 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_389 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_391 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_392 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_394 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_397 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_398 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_400 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_401 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_402 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_403 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_404 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_405 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_406 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_408 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_409 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_411 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_412 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_413 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_414 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_415 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_418 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_419 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_421 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_423 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_427 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_428 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_429 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_430 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_431 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_432 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_434 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_435 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_436 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_437 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_438 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_439 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_440 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_442 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_444 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_445 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_446 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_448 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_449 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_450 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_454 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_455 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_456 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_457 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_458 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_459 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_460 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_461 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_462 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_463 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_465 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_466 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_468 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_470 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_471 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_472 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_473 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_474 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_476 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_477 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_478 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_479 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_480 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_481 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_482 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_483 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_484 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_485 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_486 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_487 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_488 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_489 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_490 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_491 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_492 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_494 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_496 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_497 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_499 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_501 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_502 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_503 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_504 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_506 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_507 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_508 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_509 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_510 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_511 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_512 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_515 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_516 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_517 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_518 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_519 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_520 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_521 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_522 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_523 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_524 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_525 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_526 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_528 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_529 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_530 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_531 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_532 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_533 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_535 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_537 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_539 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_540 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_541 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_542 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_544 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_545 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_546 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_547 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_549 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_550 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_551 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_552 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_553 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_554 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_555 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_557 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_558 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_559 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_560 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_561 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_562 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_564 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_565 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_566 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_567 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_568 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_569 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_570 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_571 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_573 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_574 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_575 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_576 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_578 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_581 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_582 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_583 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_584 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_586 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_587 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_588 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_590 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_591 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_592 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_594 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_597 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_598 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_599 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_600 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_601 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_602 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_603 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_605 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_606 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_607 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_608 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_610 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_612 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_613 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_614 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_615 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_617 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_618 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_619 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_622 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_625 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_626 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_627 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_628 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_629 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_630 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_632 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_633 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_634 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_636 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_637 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_638 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_639 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_640 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_642 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_645 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_647 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_648 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_649 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_650 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_651 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_654 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_655 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_656 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_659 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_660 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_661 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_665 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_666 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_667 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_668 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_669 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_670 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_671 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_672 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_673 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_674 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_678 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_681 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_682 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_683 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_684 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_686 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_687 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_689 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_690 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_691 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_692 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_694 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_695 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_697 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_699 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_700 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_701 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_703 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_704 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_705 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_706 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_707 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_708 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_709 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_710 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_711 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_713 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_717 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_719 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_720 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_722 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_723 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_724 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_725 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_726 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_728 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_729 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_730 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_731 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_732 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_733 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_734 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_735 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_736 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_737 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_739 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_740 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_741 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_742 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_744 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_745 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_746 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_747 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_750 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_751 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_753 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_754 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_756 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_757 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_758 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_759 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_761 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_762 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_766 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_769 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_770 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_771 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_772 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_773 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_774 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_775 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_776 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_777 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_778 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_779 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_780 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_781 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_783 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_784 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_786 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_788 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_789 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_790 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_791 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_793 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_794 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_795 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_796 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_797 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_799 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_800 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_802 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_803 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_804 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_806 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_807 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_810 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_812 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_815 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_816 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_817 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_818 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_819 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_821 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_822 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_823 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_826 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_830 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_832 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_833 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_834 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_836 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_837 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_840 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_841 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_842 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_843 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_844 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_845 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_846 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_847 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_848 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_849 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_850 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_851 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_852 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_854 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_855 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_856 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_857 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_859 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_860 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_861 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_862 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_864 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_865 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_866 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_867 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_868 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_871 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_872 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_873 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_874 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_875 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_879 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_880 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_882 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_883 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_885 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_887 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_889 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_890 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_891 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_893 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_894 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_896 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_897 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_898 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_900 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_902 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_904 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_905 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_906 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_907 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_908 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_909 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_910 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_911 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_912 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_913 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_915 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_916 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_917 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_918 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_919 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_920 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_924 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_925 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_927 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_928 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_929 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_930 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_931 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_932 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_933 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_934 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_935 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_936 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_937 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_939 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_940 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_941 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_942 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_943 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_946 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_947 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_948 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_949 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_950 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_954 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_955 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_958 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_959 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_960 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_961 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_963 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_964 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_965 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_966 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_969 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_970 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_971 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_972 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_974 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_975 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_978 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_979 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_980 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_981 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_983 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_984 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_985 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_986 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_987 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_988 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_989 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_990 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_991 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_992 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_993 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_994 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_996 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_999 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1001 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1003 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1004 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1005 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1006 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1008 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1009 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1010 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1011 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1012 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1014 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1015 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1016 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1017 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1018 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1020 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1023 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1024 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1025 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1027 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1028 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1029 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1030 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1031 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1032 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1033 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1034 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1035 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1036 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1038 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1039 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1040 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1041 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1042 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1043 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1044 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1045 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1047 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1049 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1050 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1051 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1052 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1053 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1054 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1055 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1056 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1057 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1058 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1059 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1060 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1061 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1062 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1063 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1064 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1065 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1067 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1068 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1069 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1070 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1072 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1076 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1077 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1078 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1080 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1083 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1084 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1085 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1086 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1088 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1089 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1090 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1091 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1092 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1093 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1094 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1095 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1097 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1098 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1099 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1100 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1102 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1103 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1105 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1106 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1108 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1109 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1110 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1112 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1113 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1114 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1115 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1116 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1117 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1118 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1119 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1121 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1122 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1123 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1124 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1125 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1126 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1127 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1128 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1130 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1131 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1134 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1135 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1137 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1138 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1139 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1141 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1142 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1143 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1144 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1145 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1146 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1147 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1148 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1149 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1150 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1151 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1152 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1154 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1155 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1157 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1159 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1160 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1161 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1163 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1164 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1165 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1167 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1168 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1170 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1171 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1175 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1176 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1177 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1178 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1181 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1182 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1184 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1186 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1187 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1188 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1189 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1190 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1191 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1193 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1194 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1195 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1196 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1197 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1198 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1199 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1200 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1201 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1202 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1205 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1206 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1209 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1210 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1214 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1215 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1216 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1217 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1218 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1220 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1221 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1222 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1223 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1224 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1225 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1226 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1227 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1228 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1229 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1230 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1231 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1232 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1234 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1235 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1237 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1239 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1240 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1241 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1242 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1244 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1245 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1247 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1248 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1249 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1250 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1253 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1255 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1256 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1257 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1258 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1260 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1261 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1262 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1263 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1264 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1266 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1267 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1268 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1269 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1271 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1273 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1274 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1275 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1276 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1277 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1278 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1279 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1280 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1281 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1282 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1285 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1286 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1288 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1290 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1291 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1294 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1295 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1296 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1297 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1298 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1299 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1300 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1301 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1303 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1304 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1305 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1306 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1307 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1308 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1309 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1311 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1314 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1315 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1316 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1317 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1318 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1319 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1320 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1321 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1323 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1325 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1327 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1328 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1329 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1331 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1332 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1334 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1335 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1336 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1337 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1339 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1340 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1341 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1342 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1343 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1345 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1346 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1347 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1348 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1349 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1350 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1351 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1352 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1353 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1354 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1356 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1357 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1358 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1359 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1360 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1363 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1364 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1367 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1368 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1369 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1370 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1371 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1372 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1375 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1377 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1378 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1379 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1380 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1381 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1382 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1383 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1387 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1388 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1389 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1392 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1395 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1398 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1399 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1400 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1402 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1403 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1405 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1406 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1407 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1409 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1410 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1411 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1412 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1413 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1414 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1415 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1416 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1418 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1419 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1421 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1422 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1423 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1424 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1425 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1426 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1427 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1428 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1429 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1430 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1431 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1433 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1434 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1435 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1436 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1438 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1440 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1442 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1443 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1444 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1445 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1446 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1447 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1448 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1449 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1450 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1451 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1452 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1454 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1457 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1458 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1459 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1460 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1461 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_3 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_4 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_5 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_6 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_7 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_8 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_10 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_11 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_12 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_13 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_14 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_15 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_16 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_17 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_18 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_19 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_20 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_21 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_22 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_24 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_25 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_28 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_29 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_30 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_32 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_34 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_35 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_36 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_37 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_38 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_39 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_40 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_41 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_42 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_43 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_44 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_45 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_47 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_48 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_49 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_51 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_52 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_55 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_56 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_57 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_59 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_60 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_61 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_62 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_64 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_65 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_66 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_67 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_68 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_69 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_70 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_76 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_78 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_79 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_82 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_86 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_87 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_88 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_89 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_90 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_91 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_92 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_94 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_95 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_97 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_98 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_99 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_100 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_101 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_103 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_106 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_107 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_108 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_109 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_110 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_111 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_112 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_113 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_114 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_115 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_116 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_117 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_118 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_119 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_120 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_121 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_122 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_123 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_124 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_125 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_126 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_127 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_128 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_129 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_132 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_133 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_136 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_137 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_139 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_141 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_142 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_144 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_145 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_146 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_147 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_148 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_149 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_150 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_151 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_152 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_154 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_155 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_156 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_158 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_159 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_160 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_161 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_163 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_164 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_166 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_167 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_168 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_170 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_171 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_172 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_173 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_174 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_175 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_176 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_177 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_178 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_179 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_181 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_182 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_183 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_184 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_185 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_186 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_187 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_188 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_189 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_190 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_192 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_193 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_196 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_197 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_198 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_199 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_200 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_201 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_203 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_204 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_205 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_206 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_207 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_208 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_209 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_210 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_211 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_212 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_213 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_215 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_216 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_217 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_218 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_220 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_223 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_226 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_227 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_229 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_230 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_231 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_233 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_234 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_235 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_236 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_237 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_238 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_239 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_240 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_241 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_243 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_244 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_245 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_246 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_247 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_248 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_249 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_252 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_254 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_255 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_256 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_257 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_258 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_260 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_261 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_262 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_263 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_265 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_266 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_267 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_268 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_269 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_270 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_271 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_274 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_277 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_278 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_279 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_280 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_281 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_282 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_283 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_284 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_286 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_289 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_290 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_291 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_292 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_293 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_294 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_295 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_297 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_300 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_304 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_307 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_309 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_310 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_311 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_312 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_313 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_314 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_315 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_316 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_317 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_319 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_320 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_321 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_322 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_323 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_324 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_327 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_329 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_330 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_331 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_332 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_333 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_334 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_336 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_337 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_338 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_339 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_340 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_341 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_343 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_344 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_345 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_347 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_349 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_350 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_351 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_352 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_355 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_356 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_357 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_358 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_359 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_360 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_361 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_362 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_363 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_364 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_365 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_366 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_367 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_368 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_370 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_371 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_372 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_373 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_374 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_375 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_377 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_378 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_380 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_382 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_383 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_384 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_385 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_386 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_387 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_390 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_391 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_393 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_394 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_395 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_396 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_397 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_399 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_400 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_401 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_402 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_403 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_404 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_407 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_409 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_410 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_411 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_412 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_413 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_414 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_415 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_417 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_418 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_420 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_421 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_423 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_424 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_425 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_426 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_427 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_428 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_430 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_431 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_432 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_433 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_434 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_435 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_437 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_438 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_439 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_440 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_441 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_442 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_443 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_445 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_446 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_450 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_451 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_452 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_454 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_456 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_458 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_462 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_463 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_464 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_465 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_466 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_468 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_469 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_470 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_471 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_474 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_475 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_478 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_479 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_480 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_481 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_482 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_483 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_484 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_485 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_486 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_487 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_488 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_489 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_491 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_492 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_493 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_495 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_496 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_497 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_498 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_499 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_500 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_501 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_503 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_504 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_505 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_506 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_510 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_511 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_512 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_513 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_514 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_515 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_518 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_520 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_521 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_522 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_523 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_526 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_527 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_529 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_530 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_534 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_535 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_536 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_537 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_538 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_539 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_540 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_541 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_542 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_543 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_544 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_545 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_546 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_547 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_548 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_549 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_550 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_551 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_552 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_555 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_556 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_557 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_559 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_560 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_562 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_563 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_564 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_565 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_566 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_567 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_568 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_570 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_571 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_572 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_574 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_575 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_578 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_579 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_580 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_581 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_583 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_584 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_586 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_587 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_588 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_589 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_590 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_591 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_592 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_593 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_594 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_595 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_596 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_597 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_600 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_601 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_602 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_603 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_605 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_606 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_608 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_609 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_610 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_611 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_612 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_613 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_615 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_616 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_617 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_618 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_619 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_621 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_623 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_624 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_625 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_627 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_628 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_629 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_630 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_631 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_632 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_633 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_634 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_635 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_636 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_637 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_638 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_639 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_640 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_641 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_642 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_644 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_645 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_646 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_647 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_648 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_649 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_652 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_653 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_654 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_655 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_656 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_657 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_659 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_660 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_661 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_664 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_666 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_667 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_668 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_669 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_670 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_671 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_672 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_674 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_675 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_676 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_678 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_679 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_682 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_683 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_684 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_685 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_687 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_688 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_689 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_690 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_691 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_694 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_696 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_699 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_700 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_701 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_702 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_703 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_704 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_705 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_706 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_707 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_709 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_710 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_712 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_713 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_714 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_715 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_718 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_719 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_720 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_721 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_722 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_723 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_725 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_728 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_729 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_730 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_731 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_732 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_734 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_737 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_738 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_739 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_740 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_741 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_742 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_743 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_744 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_746 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_748 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_750 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_752 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_753 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_755 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_757 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_758 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_759 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_760 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_761 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_762 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_763 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_764 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_765 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_766 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_767 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_768 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_770 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_771 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_772 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_773 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_775 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_776 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_777 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_779 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_780 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_782 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_784 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_787 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_788 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_789 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_791 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_792 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_793 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_794 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_796 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_798 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_800 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_801 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_802 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_803 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_804 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_805 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_806 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_807 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_808 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_809 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_810 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_811 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_812 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_813 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_816 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_819 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_820 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_821 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_823 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_824 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_825 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_826 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_827 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_828 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_831 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_832 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_833 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_834 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_835 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_836 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_837 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_838 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_839 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_840 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_841 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_842 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_843 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_844 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_846 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_847 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_848 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_849 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_850 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_851 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_852 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_853 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_854 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_856 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_857 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_858 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_859 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_860 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_861 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_862 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_863 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_864 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_866 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_868 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_869 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_870 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_871 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_872 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_873 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_874 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_876 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_877 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_879 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_880 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_883 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_884 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_885 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_886 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_887 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_888 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_890 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_891 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_892 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_893 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_894 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_895 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_896 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_897 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_898 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_899 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_900 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_901 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_902 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_903 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_904 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_906 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_907 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_908 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_909 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_910 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_911 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_912 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_914 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_915 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_916 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_917 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_918 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_921 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_922 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_923 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_924 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_926 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_927 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_928 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_929 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_931 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_932 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_933 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_934 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_935 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_936 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_937 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_938 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_939 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_940 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_941 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_942 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_944 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_945 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_946 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_947 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_948 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_950 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_951 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_952 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_953 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_954 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_955 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_956 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_958 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_959 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_960 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_961 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_962 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_963 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_965 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_966 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_967 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_968 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_969 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_970 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_972 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_973 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_974 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_975 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_976 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_977 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_978 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_979 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_980 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_981 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_982 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_983 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_984 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_986 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_987 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_988 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_989 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_990 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_991 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_992 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_995 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_996 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_997 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_998 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_999 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1000 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1001 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1002 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1003 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1004 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1007 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1008 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1009 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1010 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1011 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1012 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1013 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1016 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1018 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1020 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1021 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1022 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1023 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1024 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1025 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1026 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1028 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1029 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1030 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1031 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1032 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1033 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1034 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1036 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1037 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1038 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1039 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1041 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1042 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1044 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1045 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1046 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1047 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1048 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1049 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1050 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1051 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1052 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1053 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1054 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1055 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1057 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1058 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1062 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1064 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1066 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1067 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1068 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1070 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1072 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1073 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1074 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1075 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1076 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1077 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1078 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1079 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1080 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1081 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1082 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1083 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1084 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1085 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1086 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1087 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1088 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1089 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1091 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1092 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1093 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1094 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1095 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1096 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1098 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1099 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1100 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1102 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1104 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1105 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1106 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1107 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1109 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1111 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1112 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1113 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1114 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1115 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1118 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1120 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1121 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1122 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1123 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1124 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1129 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1130 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1131 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1132 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1133 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1134 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1136 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1138 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1139 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1140 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1144 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1147 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1148 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1149 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1150 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1151 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1152 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1153 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1154 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1155 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1158 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1159 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1160 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1161 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1163 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1164 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1165 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1166 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1167 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1170 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1171 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1172 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1174 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1175 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1176 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1177 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1178 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1179 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1180 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1181 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1184 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1185 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1186 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1187 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1188 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1189 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1190 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1191 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1193 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1194 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1195 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1196 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1197 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1198 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1199 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1200 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1202 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1203 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1204 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1205 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1206 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1207 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1208 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1209 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1210 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1211 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1212 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1213 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1214 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1215 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1216 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1217 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1218 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1219 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1222 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1223 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1224 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1225 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1226 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1228 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1229 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1230 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1231 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1232 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1233 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1234 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1235 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1237 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1239 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1240 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1244 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1245 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1246 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1247 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1248 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1249 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1250 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1251 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1252 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1253 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1254 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1256 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1257 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1260 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1262 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1263 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1264 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1265 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1266 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1267 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1268 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1270 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1271 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1272 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1273 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1274 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1275 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1276 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1277 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1278 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1279 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1282 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1283 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1284 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1285 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1286 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1289 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1290 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1291 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1292 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1294 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1295 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1296 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1297 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1298 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1299 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1300 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1302 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1303 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1304 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1305 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1306 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1307 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1309 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1310 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1311 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1312 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1313 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1314 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1315 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1316 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1317 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1318 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1319 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1320 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1322 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1323 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1325 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1326 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1327 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1328 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1330 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1331 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1332 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1333 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1335 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1336 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1337 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1338 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1339 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1340 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1341 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1342 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1343 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1344 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1345 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1346 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1347 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1348 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1349 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1350 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1351 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1352 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1353 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1354 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1355 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1357 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1358 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1359 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1360 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1361 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1362 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1363 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1367 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1368 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1369 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1370 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1371 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1373 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1375 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1376 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1377 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1378 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1381 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1384 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1385 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1386 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1387 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1388 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1389 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1390 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1391 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1392 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1393 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1394 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1396 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1397 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1398 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1400 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1402 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1404 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1405 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1406 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1407 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1408 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1412 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1413 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1415 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1416 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1418 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1419 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1420 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1421 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1422 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1423 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1424 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1425 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1426 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1427 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1428 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1429 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1433 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1434 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1435 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1436 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1437 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1438 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1439 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1441 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1442 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1444 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1445 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1446 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1447 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1448 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1449 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1450 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1451 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1453 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1454 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1455 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1456 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1457 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1459 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1460 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1461 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1462 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1464 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1465 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1466 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1467 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1468 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1469 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1470 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1471 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1472 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1474 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1476 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1477 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1478 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1479 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1480 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1481 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1482 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1485 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1486 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1487 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1488 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1490 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1491 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1492 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1493 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1495 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1496 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1498 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1500 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1501 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1502 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1503 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1505 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1506 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1507 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1508 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1510 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1513 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1514 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1515 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1516 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1517 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1518 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1519 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1521 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1522 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1523 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1524 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1525 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1528 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1529 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1530 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1531 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1532 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1533 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1534 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1535 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1536 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1537 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1538 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1539 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1542 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1543 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1546 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1547 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1548 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1549 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1550 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1551 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1552 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1553 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1554 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1555 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1556 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1557 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1559 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1560 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1561 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1562 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1563 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1564 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1565 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1569 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1570 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1571 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1572 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1574 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1575 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1576 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1577 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1578 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1579 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1580 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1581 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1582 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1585 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1586 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1587 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1588 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1589 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1590 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1595 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1596 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1597 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1598 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1599 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1600 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1601 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1602 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1603 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1605 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1606 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1607 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1608 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1609 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1610 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1611 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1612 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1613 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1614 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1615 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1616 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1617 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1618 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1619 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1620 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1621 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1622 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1623 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1624 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1625 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1626 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1627 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1628 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1629 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1630 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1631 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1632 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1633 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1634 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1635 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1636 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1637 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1638 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1639 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1640 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1641 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1643 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1644 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1645 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1646 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1647 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1649 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1650 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1652 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1653 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1654 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1657 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1658 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1659 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1660 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1661 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1662 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1663 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1664 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1665 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1667 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1668 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1669 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1670 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1672 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1673 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1675 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1676 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1677 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1678 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1679 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1682 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1683 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1684 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1685 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1686 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1687 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1688 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1689 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1691 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1692 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1695 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1696 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1697 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1698 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1699 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1701 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1702 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1703 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1704 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1705 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1706 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1707 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1708 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1709 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1711 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1712 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1714 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1715 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1716 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1717 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1718 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1719 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1720 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1721 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1722 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1723 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1724 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1725 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1726 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1727 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1729 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1730 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1731 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1732 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1733 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1734 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1735 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1736 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1737 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1738 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1739 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1740 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1741 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1742 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1743 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1744 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1746 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1747 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1748 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1749 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1751 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1753 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1754 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1755 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1757 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1758 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1759 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1760 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1761 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1765 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1766 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1767 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1768 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1769 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1770 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1771 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1772 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1773 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1775 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1776 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1778 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1779 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1780 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1781 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1782 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1783 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1784 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1785 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1786 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1787 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1788 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1789 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1790 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1791 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1792 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1793 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1794 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1795 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1796 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1797 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1799 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1800 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1801 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1802 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1803 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1806 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1808 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1809 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1810 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1811 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1812 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1813 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1815 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1816 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1817 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1818 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1819 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1820 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1822 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1825 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1826 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1827 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1828 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1829 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1830 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1831 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1832 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1834 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1835 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1836 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1837 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1838 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1839 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1840 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1841 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1842 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1844 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1845 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1846 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1847 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1848 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1849 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1850 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1851 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1852 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1853 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1854 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1855 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1856 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1857 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1858 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1859 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1860 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1861 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1862 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1863 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1864 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1865 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1866 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1867 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1868 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1869 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1870 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1872 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1873 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1875 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1876 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1877 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1878 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1880 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1883 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1884 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1885 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1886 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1889 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1890 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1893 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1895 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1896 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1897 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1898 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1899 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1901 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1902 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1903 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1905 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1906 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1908 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1909 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1910 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1912 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1913 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1914 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1915 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1916 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1919 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1920 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1921 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1922 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1923 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1924 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1925 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1926 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1927 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1928 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1929 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1931 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1932 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1933 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1934 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1935 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1936 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1937 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1938 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1939 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1940 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1942 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1943 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1944 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1945 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1947 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1949 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1950 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1951 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1952 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1953 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1954 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1955 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1956 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1957 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1958 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1959 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1960 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1963 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1964 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1965 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1968 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1969 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1971 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1972 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1973 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1974 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1975 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1976 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1977 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1978 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1979 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1980 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1981 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1982 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1983 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1984 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1985 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1986 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1987 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1989 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1990 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1991 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1992 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1994 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1995 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1996 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1998 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1999 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2002 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2003 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2004 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2005 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2006 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2007 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2010 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2011 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2012 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2013 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2015 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2016 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2017 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2018 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2019 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2021 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2022 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2023 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2024 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2026 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2027 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2028 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2030 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2034 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2035 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2036 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2037 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2038 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2039 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2041 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2043 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2044 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2045 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2046 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2047 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2048 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2049 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2050 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2051 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2052 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2053 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2054 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2055 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2057 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2058 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2059 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2061 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2062 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2063 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2064 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2066 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2068 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2069 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2070 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2071 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2074 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2075 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2076 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2077 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2078 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2080 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2081 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2082 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2083 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2085 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2086 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2087 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2088 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2089 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2090 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2091 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2093 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2094 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2096 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2097 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2098 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2099 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2100 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2101 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2102 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2104 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2105 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2106 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2109 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2110 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2111 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2112 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2113 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2114 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2116 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2117 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2118 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2121 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2122 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2123 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2124 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2125 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2127 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2128 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2129 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2130 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2132 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2134 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2135 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2136 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2137 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2141 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2142 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2143 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2144 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2145 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2146 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2147 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2148 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2149 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2150 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2151 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2152 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2155 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2156 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2157 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2158 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2159 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2160 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2161 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2162 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2163 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2164 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2165 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2166 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2167 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2169 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2170 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2173 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2174 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2175 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2176 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2177 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2178 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2179 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2180 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2181 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2182 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2183 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2184 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2185 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2187 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2188 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2189 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2190 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2191 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2192 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2193 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2194 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2195 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2196 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2197 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2198 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2202 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2203 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2204 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2205 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2206 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2208 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2210 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2212 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2213 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2215 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2216 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2217 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2218 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2219 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2220 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2221 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2222 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2223 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2224 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2225 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2226 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2227 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2228 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2231 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2233 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2235 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2237 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2238 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2242 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2243 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2244 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2245 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2247 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2248 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2250 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2251 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2253 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2254 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2255 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2256 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2257 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2258 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2259 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2260 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2261 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2262 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2263 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2264 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2266 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2267 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2268 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2269 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2270 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2272 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2273 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2274 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2276 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2277 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2278 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2279 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2280 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2281 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2282 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2283 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2286 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2287 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2288 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2289 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2290 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2291 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2293 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2294 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2296 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2297 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2298 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2299 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2300 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2301 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2303 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2304 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2305 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2306 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2307 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2308 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2309 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2310 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2311 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2313 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2314 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2315 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2316 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2317 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2319 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2320 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2322 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2324 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2325 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2326 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2327 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2329 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2330 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2331 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2332 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2334 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2335 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2336 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2337 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2338 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2339 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2340 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2342 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2343 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2344 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2345 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2347 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2349 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2350 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2351 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2352 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2353 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2354 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2355 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2356 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2357 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2358 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2360 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2361 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2362 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2363 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2364 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2365 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2366 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2369 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2370 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2371 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2372 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2373 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2374 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2376 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2377 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2379 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2381 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2383 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2384 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2385 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2386 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2387 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2392 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2394 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2396 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2397 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2398 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2399 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2400 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2401 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2402 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2403 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2404 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2405 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2406 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2407 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2409 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2410 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2411 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2412 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2415 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2416 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2417 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2420 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2421 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2423 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2425 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2426 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2427 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2428 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2429 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2430 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2431 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2432 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2433 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2434 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2435 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2436 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2437 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2438 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2439 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2440 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2442 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2444 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2446 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2448 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2449 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2450 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2451 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2452 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2453 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2455 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2456 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2457 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2458 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2459 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2460 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2461 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2462 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2463 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2464 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2465 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2466 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2467 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2468 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2469 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2472 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2473 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2474 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2475 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2476 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2477 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2479 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2480 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2481 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2482 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2483 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2484 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2485 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2487 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2488 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2489 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2490 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2491 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2494 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2495 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2496 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2498 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2499 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2500 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2502 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2503 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2504 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2505 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2508 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2509 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2510 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2511 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2512 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2513 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2514 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2517 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2519 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2520 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2521 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2522 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2523 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2524 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2525 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2526 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2527 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2528 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2529 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2530 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2532 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2533 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2534 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2535 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2536 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2537 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2539 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2540 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2541 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2542 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2544 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2545 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2546 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2547 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2548 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2549 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2551 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2552 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2554 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2555 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2556 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2558 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2561 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2563 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2564 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2565 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2566 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2567 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2568 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2569 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2570 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2571 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2572 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2573 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2575 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2576 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2577 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2578 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2579 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2580 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2581 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2582 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2583 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2584 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2586 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2587 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2588 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2589 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2590 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2591 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2592 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2594 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2595 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2597 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2598 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2601 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2602 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2603 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2604 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2605 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2607 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2608 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2609 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2610 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2612 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2613 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2614 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2615 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2616 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2617 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2618 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2619 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2620 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2622 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2623 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2624 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2625 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2628 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2630 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2631 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2632 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2635 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2636 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2637 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2638 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2639 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2640 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2641 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2643 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2644 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2645 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2646 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2647 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2648 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2649 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2650 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2651 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2652 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2653 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2654 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2655 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2656 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2657 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2658 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2662 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2663 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2667 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2668 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2669 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2670 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2671 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2672 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2673 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2674 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2676 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2677 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2679 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2680 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2681 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2682 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2683 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2684 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2685 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2686 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2687 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2688 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2689 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2691 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2692 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2693 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2694 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2696 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2697 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2698 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2699 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2700 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2701 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2702 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2703 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2704 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2705 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2706 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2707 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2708 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2709 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2710 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2711 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2712 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2713 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2714 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2717 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2718 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2719 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2720 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2721 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2722 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2723 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2724 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2725 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2726 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2727 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2728 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2729 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2730 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2731 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2732 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2734 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2736 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2737 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2738 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2739 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2740 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2741 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2742 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2743 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2744 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2745 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2746 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2747 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2748 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2749 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2750 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2751 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2752 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2753 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2754 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_5 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_7 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_9 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_10 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_12 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_13 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_14 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_15 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_17 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_21 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_23 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_25 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_27 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_28 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_30 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_31 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_33 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_34 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_35 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_36 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_37 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_39 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_40 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_41 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_42 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_43 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_44 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_45 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_46 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_47 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_48 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_51 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_53 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_54 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_55 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_57 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_58 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_59 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_60 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_61 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_63 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_64 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_65 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_66 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_67 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_68 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_69 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_70 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_72 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_73 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_74 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_76 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_77 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_79 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_80 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_81 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_82 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_83 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_84 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_85 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_86 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_88 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_89 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_90 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_92 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_93 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_94 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_95 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_96 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_98 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_99 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_100 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_101 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_102 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_104 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_106 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_107 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_108 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_109 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_110 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_111 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_113 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_114 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_115 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_117 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_118 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_119 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_120 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_121 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_122 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_124 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_125 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_126 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_127 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_128 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_129 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_130 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_131 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_132 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_134 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_135 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_136 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_137 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_138 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_139 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_140 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_141 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_142 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_143 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_144 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_145 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_146 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_147 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_148 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_149 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_150 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_152 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_153 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_154 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_155 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_156 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_157 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_159 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_161 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_162 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_163 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_164 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_165 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_166 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_167 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_168 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_169 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_171 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_172 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_173 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_174 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_175 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_176 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_177 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_179 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_180 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_181 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_183 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_184 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_185 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_186 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_187 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_188 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_189 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_190 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_191 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_192 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_194 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_195 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_196 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_197 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_200 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_201 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_202 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_203 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_204 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_206 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_207 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_209 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_210 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_211 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_212 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_213 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_214 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_216 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_218 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_219 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_221 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_222 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_223 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_225 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_227 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_228 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_229 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_233 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_234 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_235 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_236 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_237 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_238 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_239 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_240 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_241 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_242 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_243 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_245 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_246 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_247 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_249 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_250 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_251 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_252 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_253 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_254 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_255 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_257 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_258 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_259 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_260 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_261 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_262 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_263 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_264 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_265 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_266 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_267 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_268 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_269 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_270 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_271 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_272 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_273 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_274 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_275 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_276 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_277 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_278 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_279 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_281 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_283 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_284 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_285 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_286 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_287 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_288 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_289 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_290 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_291 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_292 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_293 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_295 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_296 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_298 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_299 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_300 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_302 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_303 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_304 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_305 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_306 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_307 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_309 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_310 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_311 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_312 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_313 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_314 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_315 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_316 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_317 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_318 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_319 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_320 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_321 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_322 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_323 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_325 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_326 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_327 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_328 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_329 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_330 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_333 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_334 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_335 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_336 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_337 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_339 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_340 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_341 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_342 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_344 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_345 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_346 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_347 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_350 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_351 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_352 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_354 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_356 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_357 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_360 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_361 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_362 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_363 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_366 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_368 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_369 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_370 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_371 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_373 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_374 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_375 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_376 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_379 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_380 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_381 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_382 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_383 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_384 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_385 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_386 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_387 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_388 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_389 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_390 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_392 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_393 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_394 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_396 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_397 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_398 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_399 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_400 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_401 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_402 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_403 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_405 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_408 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_409 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_410 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_411 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_412 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_413 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_414 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_416 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_418 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_419 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_421 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_422 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_423 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_424 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_425 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_427 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_428 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_429 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_430 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_431 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_432 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_433 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_434 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_435 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_436 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_437 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_438 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_439 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_440 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_441 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_442 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_444 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_446 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_448 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_449 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_450 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_452 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_453 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_454 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_455 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_456 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_458 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_459 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_461 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_462 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_463 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_464 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_465 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_466 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_467 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_468 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_469 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_470 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_471 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_472 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_473 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_474 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_475 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_477 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_478 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_479 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_481 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_482 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_483 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_484 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_485 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_487 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_488 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_489 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_490 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_493 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_494 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_496 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_497 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_498 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_499 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_500 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_501 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_503 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_504 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_505 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_506 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_507 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_508 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_509 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_510 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_512 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_513 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_514 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_515 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_516 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_517 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_518 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_519 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_520 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_521 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_522 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_524 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_525 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_526 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_527 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_528 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_530 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_531 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_532 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_533 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_534 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_535 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_536 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_537 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_538 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_539 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_540 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_541 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_542 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_543 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_544 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_545 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_546 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_547 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_551 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_552 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_553 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_554 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_555 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_556 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_558 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_559 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_560 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_561 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_562 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_563 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_564 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_565 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_566 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_569 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_570 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_571 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_572 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_574 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_575 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_576 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_577 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_578 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_580 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_581 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_582 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_583 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_584 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_585 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_586 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_587 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_588 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_590 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_591 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_594 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_595 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_596 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_597 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_598 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_599 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_600 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_602 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_604 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_605 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_607 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_609 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_611 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_612 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_613 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_614 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_615 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_617 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_618 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_619 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_620 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_621 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_623 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_624 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_625 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_626 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_627 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_628 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_629 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_630 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_631 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_632 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_633 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_635 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_636 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_637 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_638 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_639 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_640 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_641 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_642 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_645 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_647 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_650 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_651 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_652 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_653 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_654 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_655 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_658 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_659 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_660 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_661 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_662 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_663 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_665 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_666 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_667 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_668 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_669 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_670 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_671 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_672 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_673 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_674 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_676 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_677 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_681 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_683 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_684 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_685 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_687 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_691 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_693 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_694 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_696 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_697 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_698 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_699 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_700 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_701 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_702 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_703 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_704 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_705 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_706 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_707 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_709 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_710 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_711 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_712 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_713 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_716 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_717 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_720 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_721 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_723 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_724 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_725 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_726 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_727 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_728 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_729 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_730 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_731 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_732 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_733 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_735 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_736 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_737 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_738 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_739 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_740 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_741 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_742 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_743 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_745 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_747 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_748 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_749 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_750 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_751 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_753 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_754 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_755 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_756 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_758 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_759 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_761 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_762 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_763 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_764 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_765 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_768 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_769 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_770 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_771 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_772 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_773 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_774 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_775 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_776 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_777 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_779 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_780 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_782 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_784 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_785 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_787 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_789 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_790 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_791 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_793 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_794 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_795 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_796 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_797 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_798 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_799 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_801 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_802 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_803 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_805 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_806 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_807 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_808 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_809 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_810 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_812 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_813 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_815 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_816 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_817 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_819 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_820 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_821 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_824 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_825 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_827 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_830 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_831 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_833 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_834 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_835 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_836 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_837 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_840 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_841 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_842 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_843 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_844 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_845 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_846 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_847 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_849 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_851 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_852 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_853 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_854 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_855 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_856 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_857 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_858 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_861 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_862 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_863 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_864 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_865 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_867 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_868 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_869 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_870 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_871 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_873 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_874 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_875 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_876 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_877 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_878 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_880 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_883 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_884 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_885 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_886 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_887 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_888 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_889 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_890 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_891 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_892 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_894 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_895 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_896 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_897 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_898 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_899 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_900 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_902 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_905 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_906 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_908 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_910 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_911 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_912 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_913 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_914 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_915 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_916 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_917 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_918 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_920 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_921 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_922 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_924 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_925 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_926 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_927 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_928 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_929 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_930 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_931 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_932 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_935 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_936 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_939 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_942 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_943 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_944 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_945 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_946 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_947 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_948 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_950 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_952 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_953 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_955 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_956 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_958 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_959 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_960 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_961 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_963 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_966 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_968 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_970 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_971 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_972 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_973 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_974 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_975 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_976 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_977 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_978 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_979 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_980 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_981 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_982 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_983 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_984 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_986 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_987 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_990 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_991 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_992 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_994 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_995 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_997 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_998 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_999 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1000 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1001 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1002 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1003 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1004 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1005 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1006 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1007 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1009 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1010 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1014 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1015 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1016 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1019 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1020 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1024 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1025 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1027 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1028 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1029 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1030 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1031 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1033 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1034 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1035 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1036 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1037 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1038 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1039 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1040 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1041 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1042 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1043 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1044 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1045 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1046 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1047 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1048 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1049 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1050 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1051 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1052 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1053 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1055 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1056 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1058 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1059 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1061 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1062 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1063 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1064 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1065 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1066 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1068 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1069 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1071 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1072 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1074 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1075 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1076 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1077 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1078 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1079 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1082 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1083 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1084 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1086 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1088 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1089 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1092 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1093 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1095 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1096 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1097 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1099 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1100 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1102 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1103 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1104 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1105 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1106 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1107 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1108 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1109 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1111 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1112 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1113 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1114 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1115 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1117 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1118 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1119 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1121 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1122 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1123 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1124 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1126 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1127 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1128 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1129 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1130 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1131 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1132 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1133 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1134 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1137 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1138 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1140 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1142 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1143 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1144 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1145 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1146 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1147 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1148 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1149 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1151 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1152 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1153 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1156 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1157 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1158 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1159 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1161 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1162 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1163 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1164 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1165 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1166 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1167 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1168 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1170 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1171 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1172 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1173 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1174 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1177 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1178 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1179 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1180 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1181 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1182 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1184 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1185 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1187 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1188 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1190 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1191 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1192 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1193 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1194 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1196 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1199 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1200 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1201 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1202 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1203 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1204 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1205 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1206 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1207 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1208 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1210 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1211 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1212 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1213 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1214 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1215 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1216 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1217 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1218 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1219 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1220 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1221 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1222 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1224 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1225 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1226 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1229 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1231 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1232 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1234 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1235 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1236 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1238 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1241 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1242 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1243 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1244 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1245 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1247 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1248 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1250 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1251 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1252 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1253 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1255 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1256 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1257 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1259 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1260 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1261 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1262 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1263 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1264 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1265 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1266 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1268 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1269 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1270 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1271 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1272 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1273 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1274 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1275 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1276 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1277 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1278 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1279 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1280 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1281 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1282 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1285 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1286 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1287 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1288 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1289 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1290 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1291 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1293 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1295 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1296 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1297 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1298 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1299 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1301 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1302 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1303 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1306 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1307 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1308 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1309 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1310 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1311 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1312 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1313 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1315 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1316 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1317 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1318 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1319 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1321 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1322 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1323 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1324 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1325 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1326 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1327 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1328 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1329 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1330 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1331 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1332 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1333 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1334 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1335 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1336 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1337 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1339 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1340 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1341 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1342 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1343 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1344 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1345 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1346 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1347 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1348 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1349 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1350 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1351 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1352 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1353 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1354 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1355 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1356 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1357 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1359 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1360 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1361 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1362 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1364 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1365 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1366 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1367 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1368 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1370 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1371 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1372 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1373 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1376 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1377 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1378 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1383 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1384 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1385 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1386 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1387 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1388 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1390 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1391 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1392 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1393 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1394 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1395 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1396 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1397 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1398 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1400 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1401 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1402 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1403 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1404 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1405 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1406 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1407 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1409 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1410 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1411 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1414 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1415 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1416 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1417 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1418 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1419 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1420 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1421 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1422 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1423 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1424 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1425 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1426 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1427 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1428 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1429 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1430 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1431 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1433 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1434 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1435 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1436 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1437 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1438 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1439 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1441 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1442 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1443 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1444 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1445 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1446 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1447 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1448 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1451 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1452 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1453 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1454 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1455 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1458 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1459 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1460 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1462 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1463 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1464 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1465 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1466 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1467 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1468 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1469 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1470 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1471 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1472 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1473 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1474 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1475 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1476 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1478 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1479 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1482 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1483 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1484 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1485 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1487 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1488 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1489 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1490 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1491 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1492 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1495 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1496 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1497 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1498 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1499 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1500 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1501 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1502 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1503 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1505 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1507 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1508 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1509 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1511 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1513 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1514 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1517 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1518 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1520 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1521 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1522 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1523 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1524 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1526 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1527 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1530 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1531 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1534 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1537 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1538 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1539 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1540 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1541 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1543 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1544 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1547 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1548 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1549 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1550 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1551 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1552 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1553 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1554 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1555 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1558 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1559 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1561 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1562 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1563 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1564 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1565 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1566 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1567 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1568 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1569 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1570 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1571 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1572 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1573 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1574 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1575 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1576 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1577 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1579 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1580 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1581 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1582 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1583 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1584 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1586 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1587 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1588 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1589 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1590 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1591 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1592 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1593 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1594 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1595 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1596 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1597 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1598 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1599 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1600 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1601 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1602 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1603 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1604 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1605 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1606 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1607 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1609 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1610 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1611 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1612 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1613 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1614 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1617 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1618 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1620 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1621 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1624 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1625 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1626 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1627 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1628 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1629 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1630 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1632 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1633 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1634 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1635 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1637 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1638 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1639 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1640 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1641 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1643 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1644 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1645 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1646 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1647 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1648 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1649 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1650 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1651 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1652 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1653 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1655 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1657 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1658 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1659 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1660 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1661 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1662 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1663 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1664 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1665 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1666 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1667 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1668 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1669 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1670 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1671 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1672 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1673 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1675 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1677 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1679 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1681 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1682 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1683 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1684 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1685 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1686 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1687 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1688 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1691 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1692 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1693 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1694 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1695 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1696 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1697 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1698 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1699 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1700 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1702 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1704 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1705 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1706 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1707 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1708 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1709 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1711 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1713 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1714 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1715 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1716 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1717 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1719 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1721 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1722 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1723 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1724 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1725 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1727 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1728 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1729 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1730 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1731 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1732 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1733 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1734 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1735 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1736 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1737 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1738 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1739 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1740 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1741 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1742 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1743 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1744 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1745 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1746 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1747 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1748 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1749 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1752 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1753 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1754 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1755 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1756 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1757 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1758 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1759 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1761 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1762 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1764 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1767 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1769 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1771 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1772 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1773 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1774 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1775 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1776 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1777 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1778 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1779 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1780 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1782 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1783 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1784 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1785 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1786 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1787 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1788 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1792 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1795 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1796 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1797 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1798 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1799 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1800 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1801 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1802 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1803 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1804 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1805 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1806 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1807 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1808 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1809 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1810 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1812 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1813 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1814 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1815 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1817 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1819 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1820 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1821 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1822 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1823 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1825 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1827 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1828 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1829 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1830 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1831 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1832 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1833 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1834 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1835 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1836 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1837 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1838 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1839 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1840 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1841 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1842 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1843 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1844 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1845 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1847 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1848 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1849 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1850 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1851 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1852 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1854 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1856 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1858 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1859 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1860 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1861 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1862 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1863 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1864 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1865 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1867 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1868 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1869 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1870 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1874 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1875 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1876 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1877 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1878 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1879 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1881 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1883 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1884 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1885 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1889 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1890 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1891 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1892 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1893 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1894 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1895 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1897 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1898 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1899 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1900 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1902 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1903 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1904 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1905 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1906 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1907 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1908 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1909 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1910 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1911 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1913 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1914 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1916 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1917 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1918 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1920 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1921 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1922 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1923 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1924 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1925 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1926 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1927 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1929 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1930 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1931 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1932 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1933 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1934 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1935 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1936 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1937 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1939 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1940 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1941 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1942 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1943 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1945 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1946 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1948 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1949 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1951 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1953 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1954 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1955 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1957 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1958 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1959 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1960 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1961 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1963 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1964 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1965 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1966 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1968 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1969 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1970 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1971 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1972 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1974 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1975 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1977 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1978 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1980 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1981 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1982 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1983 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1984 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1985 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1986 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1987 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1988 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1990 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1991 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1992 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1997 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1998 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1999 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2000 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2001 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2002 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2003 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2004 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2005 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2006 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2008 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2009 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2010 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2011 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2015 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2016 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2017 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2018 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2019 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2020 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2021 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2023 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2024 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2025 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2026 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2027 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2028 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2029 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2030 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2032 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2033 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2035 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2037 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2038 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2039 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2040 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2041 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2042 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2044 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2045 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2046 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2047 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2049 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2051 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2052 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2053 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2054 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2056 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2057 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2058 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2059 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2060 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2061 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2062 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2064 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2065 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2066 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2067 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2068 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2069 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_2 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_3 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_4 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_6 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_8 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_11 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_14 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_15 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_18 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_19 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_21 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_22 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_23 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_24 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_25 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_26 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_27 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_28 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_30 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_32 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_33 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_34 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_35 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_36 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_37 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_39 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_40 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_41 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_43 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_44 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_45 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_46 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_47 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_48 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_49 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_50 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_51 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_52 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_53 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_54 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_55 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_56 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_57 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_58 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_59 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_60 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_61 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_63 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_64 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_65 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_67 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_68 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_69 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_70 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_71 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_72 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_74 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_75 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_76 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_77 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_78 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_80 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_81 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_83 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_84 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_85 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_86 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_87 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_88 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_89 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_91 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_92 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_93 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_94 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_95 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_96 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_97 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_98 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_99 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_100 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_101 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_103 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_106 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_107 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_109 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_110 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_112 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_113 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_114 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_115 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_116 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_117 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_118 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_121 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_123 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_125 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_127 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_128 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_129 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_130 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_131 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_132 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_133 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_134 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_135 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_137 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_140 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_141 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_142 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_143 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_144 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_145 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_146 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_147 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_148 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_150 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_151 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_152 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_153 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_154 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_155 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_156 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_157 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_158 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_159 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_160 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_162 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_163 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_164 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_165 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_167 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_168 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_169 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_172 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_173 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_174 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_175 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_176 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_177 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_178 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_179 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_180 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_182 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_183 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_185 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_187 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_188 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_192 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_193 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_195 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_197 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_198 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_200 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_201 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_202 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_203 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_204 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_205 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_206 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_207 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_208 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_209 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_210 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_213 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_215 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_216 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_217 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_218 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_219 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_220 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_221 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_222 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_224 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_225 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_226 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_230 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_231 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_232 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_233 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_234 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_235 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_236 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_237 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_238 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_239 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_240 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_242 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_243 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_244 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_245 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_246 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_247 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_248 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_250 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_251 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_252 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_253 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_254 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_255 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_256 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_257 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_258 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_259 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_260 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_261 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_262 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_264 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_267 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_268 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_270 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_271 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_272 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_273 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_275 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_276 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_277 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_278 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_279 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_281 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_283 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_284 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_285 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_286 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_287 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_288 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_289 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_291 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_293 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_295 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_296 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_297 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_299 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_300 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_301 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_302 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_303 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_304 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_305 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_306 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_308 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_309 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_310 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_311 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_312 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_313 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_314 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_315 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_316 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_317 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_319 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_320 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_322 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_323 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_324 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_325 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_326 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_327 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_330 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_332 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_334 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_338 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_339 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_340 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_341 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_343 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_344 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_345 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_346 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_347 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_348 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_349 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_351 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_352 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_353 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_354 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_357 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_358 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_359 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_360 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_361 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_363 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_365 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_366 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_367 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_368 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_369 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_371 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_372 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_373 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_374 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_375 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_377 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_378 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_379 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_381 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_382 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_384 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_385 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_386 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_387 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_388 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_389 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_390 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_392 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_393 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_395 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_396 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_397 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_398 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_399 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_400 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_401 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_402 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_403 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_405 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_406 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_407 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_408 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_409 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_410 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_413 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_414 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_415 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_417 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_418 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_419 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_420 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_421 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_422 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_423 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_424 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_425 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_426 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_429 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_430 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_431 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_432 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_433 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_435 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_436 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_438 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_440 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_441 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_444 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_445 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_446 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_447 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_449 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_450 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_451 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_452 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_453 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_454 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_455 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_457 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_458 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_460 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_461 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_462 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_463 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_464 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_466 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_467 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_469 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_470 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_471 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_472 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_475 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_476 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_477 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_478 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_479 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_480 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_481 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_482 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_483 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_484 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_485 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_486 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_487 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_489 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_491 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_492 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_493 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_495 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_496 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_497 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_498 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_500 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_501 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_503 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_504 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_505 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_506 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_507 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_508 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_509 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_510 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_515 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_516 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_517 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_518 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_519 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_521 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_524 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_525 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_527 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_528 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_529 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_530 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_531 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_533 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_534 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_535 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_539 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_542 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_543 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_544 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_545 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_547 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_548 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_549 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_550 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_551 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_552 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_554 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_555 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_557 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_558 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_559 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_560 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_563 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_564 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_566 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_567 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_569 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_570 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_571 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_572 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_573 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_574 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_575 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_577 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_578 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_579 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_580 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_582 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_584 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_585 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_586 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_587 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_588 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_589 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_590 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_591 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_592 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_596 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_597 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_598 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_600 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_601 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_602 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_604 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_605 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_606 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_608 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_609 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_610 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_612 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_613 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_614 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_615 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_616 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_617 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_621 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_623 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_626 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_629 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_630 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_631 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_632 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_633 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_635 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_636 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_637 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_638 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_639 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_641 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_642 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_643 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_646 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_648 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_649 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_650 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_651 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_654 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_656 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_658 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_661 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_662 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_663 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_665 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_666 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_667 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_668 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_670 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_671 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_673 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_674 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_675 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_676 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_679 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_681 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_686 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_687 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_691 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_694 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_696 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_697 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_698 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_699 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_700 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_701 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_703 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_704 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_705 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_707 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_708 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_710 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_712 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_713 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_714 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_715 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_716 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_717 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_718 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_719 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_720 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_721 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_722 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_723 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_724 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_727 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_728 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_729 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_730 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_731 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_732 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_733 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_734 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_735 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_739 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_740 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_742 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_743 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_744 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_745 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_746 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_747 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_748 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_749 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_750 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_751 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_752 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_754 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_756 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_757 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_758 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_759 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_760 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_762 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_763 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_765 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_768 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_769 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_771 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_773 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_774 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_775 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_777 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_780 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_782 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_783 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_784 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_785 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_786 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_787 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_789 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_792 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_793 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_794 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_795 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_796 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_797 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_798 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_799 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_801 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_802 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_803 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_804 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_805 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_806 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_807 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_808 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_809 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_811 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_812 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_813 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_814 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_816 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_817 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_821 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_822 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_823 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_824 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_825 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_827 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_829 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_830 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_831 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_833 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_834 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_836 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_837 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_838 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_839 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_841 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_843 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_844 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_845 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_847 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_849 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_850 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_853 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_857 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_859 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_860 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_861 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_862 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_863 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_864 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_865 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_866 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_867 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_869 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_870 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_871 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_872 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_873 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_874 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_875 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_877 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_878 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_879 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_880 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_882 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_883 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_884 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_887 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_889 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_890 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_891 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_892 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_893 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_894 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_897 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_898 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_899 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_900 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_901 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_902 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_903 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_904 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_905 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_906 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_907 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_908 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_909 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_910 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_911 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_912 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_914 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_916 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_917 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_918 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_919 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_920 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_921 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_922 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_923 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_924 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_925 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_927 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_929 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_930 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_931 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_932 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_933 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_934 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_935 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_936 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_938 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_939 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_940 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_944 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_945 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_946 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_947 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_948 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_949 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_951 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_952 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_953 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_956 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_957 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_958 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_959 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_960 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_962 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_963 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_964 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_965 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_966 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_967 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_968 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_970 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_971 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_972 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_974 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_975 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_976 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_977 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_978 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_980 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_982 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_983 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_984 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_986 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_987 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_988 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_989 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_990 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_991 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_992 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_993 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_994 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_996 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_998 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_999 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1000 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1002 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1003 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1004 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1006 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1009 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1010 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1011 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1012 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1013 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1014 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1017 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1019 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1020 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1021 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1022 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1024 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1026 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1027 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1029 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1031 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1034 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1035 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1037 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1038 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1039 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1040 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1042 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1043 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1044 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1045 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1046 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1047 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1048 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1049 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1050 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1052 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1054 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1055 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1056 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1058 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1059 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1060 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1061 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1063 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1065 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1067 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1068 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1069 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1070 DCAPBWP7T $PINS VSS=VSS VDD=VDD
.ENDS
.GLOBAL VDD
.GLOBAL VSS
