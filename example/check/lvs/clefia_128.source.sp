$ Spice netlist generated by v2lvs
$ v2013.2_18.13    Thu May 16 11:29:55 PDT 2013

.SUBCKT clefia_sbox1_0 sout<7> sout<6> sout<5> sout<4> sout<3> sout<2> sout<1>
+ sout<0> sin<7> sin<6> sin<5> sin<4> sin<3> sin<2> sin<1> sin<0> VDD VSS
Xicc_route_opt3 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n340 Z=n257
XU33 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n295 ZN=n297 A2=n17
XU352 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n289 B1=n203 B2=n355 B3=n319 ZN=n290
XU179 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n34 A1=n242 A2=n87 A4=n322 A3=n191
XU156 NR4D0BWP7T $PINS VSS=VSS A4=n122 VDD=VDD ZN=n24 A3=n179 A2=n322 A1=n312
XU160 OAI31D1BWP7T $PINS B=n294 A3=n25 ZN=n38 A2=n26 VDD=VDD A1=n153 VSS=VSS
XU19 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n153 A2=n44
XU268 AOI32D1BWP7T $PINS B2=n111 B1=n362 ZN=sout<0> A1=n246 A2=n111 VDD=VDD
+ A3=n244 VSS=VSS
XU63 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n263 A2=n41
XU319 AOI21D1BWP7T $PINS VSS=VSS A2=n200 VDD=VDD A1=n294 B=n199 ZN=n210
Xicc_place15 INVD1P5BWP7T $PINS VDD=VDD VSS=VSS I=n78 ZN=n130
XU299 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n160 ZN=n253 A1=n314 A3=n190 A4=n287
XU199 OAI31D1BWP7T $PINS B=n346 A3=n47 ZN=n69 A2=n359 VDD=VDD A1=n48 VSS=VSS
XU198 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n264 ZN=n47 A1=n79 A3=n46 A4=n105
XU221 NR4D1BWP7T $PINS VSS=VSS A4=n338 VDD=VDD ZN=n56 A3=n116 A2=n203 A1=n142
XU98 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n332 ZN=n142
XU280 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n128 ZN=n129 A1=n205 A3=n230 A4=n313
XU398 OAI211D1BWP7T $PINS A2=n260 ZN=n416 A1=n143 B=n202 VDD=VDD C=n161 VSS=VSS
XU220 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n113 ZN=n338 A1=n55 A3=n227 A4=n163
XU334 AOI31D2BWP7T $PINS B=n362 ZN=n251 A1=n238 A2=n237 VDD=VDD A3=n236 VSS=VSS
XU323 OAI211D1BWP7T $PINS A2=n18 ZN=sout<2> A1=n211 B=n210 VDD=VDD C=n209
+ VSS=VSS
XU328 NR4D1BWP7T $PINS VSS=VSS A4=n216 VDD=VDD ZN=n220 A3=n217 A2=n218 A1=n219
XU16 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=sin<1> ZN=n145 A2=sin<2>
XU14 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n300 A2=n66
XU12 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n261 A2=n286
XU9 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n29 A2=n62
XU7 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n17 ZN=n2 A2=sin<2>
XU4 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n192 A2=n369
XU207 INVD1BWP7T $PINS ZN=n214 VSS=VSS VDD=VDD I=n105
XU204 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n177 ZN=n50 A2=n112
XU201 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n202 A1=n235 ZN=n124
XU200 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n232 ZN=n310 A2=n225
XU197 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n105 A2=n131
XU196 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n311 A2=n45 A1=n141 ZN=n46 C=n323
XU194 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n297 ZN=n311 A2=n455
XU193 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<0> ZN=n45 A2=n364
XU191 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n190 ZN=n42 A2=n287
XU190 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n302 A1=n255 ZN=n43
XU187 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n66 ZN=n342 A2=n148
XU185 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n372 ZN=n225 A2=n41
XU180 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n237 ZN=n36 A1=n82 A3=n34 A4=n314
XU176 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n212 ZN=n32 A1=n276 A3=n289 A4=n313
XU175 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n74 ZN=n212 A1=n160
XU172 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n202 A2=n148
XU171 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n385 A1=n81 ZN=n33 A3=n341
XU164 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n82 A2=n116
XU163 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n190 ZN=n116 A2=n327
XU162 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n141 ZN=n327 A2=n27
XU161 INVD0BWP7T $PINS ZN=n219 VSS=VSS VDD=VDD I=n163
XU158 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n362 A2=sin<6>
XU157 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n52 A1=n164 ZN=n25 A3=n24
XU155 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n70 A1=n172 ZN=n122
XU153 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n22 ZN=n52 A2=n318
XU151 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n62 ZN=n201 A2=n66
XU150 AOI31D1BWP7T $PINS B=n97 ZN=n20 A1=sin<0> A2=n61 VDD=VDD A3=n17 VSS=VSS
XU149 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n215 ZN=n97 A2=n81
XU148 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n81 A2=n66
XU146 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n337 ZN=n186 A2=n117
XU145 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n224 ZN=n170 A2=n352
XU144 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n141 ZN=n352 A2=n41
XU143 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n224 A2=n31
XU140 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n160 A1=n196 ZN=n26 A3=n49
XU139 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n49 A2=n132
XU135 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n55 A2=n179
XU134 INVD0BWP7T $PINS ZN=n28 VSS=VSS VDD=VDD I=n272
XU130 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n44 ZN=n242 A2=n143
XU129 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n215 A2=n119
XU128 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n113 A2=n12
XU127 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n70 ZN=n350 A2=n287
XU126 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n287 A2=n16
XU125 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n70 A2=n141
XU123 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n353 A2=n31
XU120 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n230 A2=n16
XU119 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n232 A2=n61
XU117 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n10 A1=n223 A3=n22 A2=n152
XU116 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n289 A1=n9 ZN=n22 A3=n271
XU115 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n271 A2=n66
XU114 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n289 A2=n131
XU113 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n183 B1=n109 B2=n419 B3=n115 ZN=n9
XU112 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n161 A1=n84 ZN=n115
XU111 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n161 A2=n27
XU108 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n128 A2=n131
XU107 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n66 ZN=n226 A2=n27
XU105 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n183 A2=n41
XU103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n270 A2=n131
XU101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n295 ZN=n112 A2=n85
XU99 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n8 A1=n162 A3=n87 A2=n142
XU97 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n141 ZN=n332 A2=n148
XU94 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n247 A2=n35
XU93 INVD0BWP7T $PINS ZN=n35 VSS=VSS VDD=VDD I=sin<7>
XU92 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n6 ZN=n7 A1=n427 A3=n314 A4=n133
XU91 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n133 A2=n31
XU90 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n314 A2=n85
XU88 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n272 ZN=n60 A2=n313
XU87 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n313 A2=n141
XU85 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n178 ZN=n11 A2=n19
XU84 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n178 A2=n369
XU83 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n372 ZN=n272 A2=n16
XU80 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n117 A2=n27
XU79 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n75 A2=n297
XU76 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n312 ZN=n328
XU61 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n104 ZN=n21 A2=n163
XU60 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n163 A2=n66
XU58 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n372 ZN=n104 A2=n130
XU51 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n190 A2=n66
XU47 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n77 A2=sin<4>
XU46 OAI211D1BWP7T $PINS A2=n29 ZN=n359 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU43 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n123 ZN=n3 A2=n337
XU39 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n123 A2=n41
XU36 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n160 A2=n31
XU30 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n153 ZN=n72 A2=n162
XU28 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n333 A2=n130
XU25 INVD0BWP7T $PINS ZN=n1 VSS=VSS VDD=VDD I=n260
XU24 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n364 ZN=n260 A2=sin<1>
XU216 INVD1BWP7T $PINS ZN=n385 VSS=VSS VDD=VDD I=n171
XU57 INVD0BWP7T $PINS ZN=n374 VSS=VSS VDD=VDD I=n286
XU52 INVD1BWP7T $PINS ZN=n372 VSS=VSS VDD=VDD I=n30
XU22 INVD0BWP7T $PINS ZN=n370 VSS=VSS VDD=VDD I=n348
XU3 INVD0BWP7T $PINS ZN=n364 VSS=VSS VDD=VDD I=sin<2>
XU372 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n356 ZN=n360 A3=n357 A2=n358 A1=n397
XU370 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n350 A2=n351 A1=sin<1> ZN=n354
+ C=n349
XU369 AOI22D0BWP7T $PINS B1=n346 A2=n347 ZN=n361 A1=n348 VDD=VDD B2=n345
+ VSS=VSS
XU368 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n343 ZN=n345 A1=n344 A3=n342 A4=n341
XU367 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n257 B1=n358 B2=n339 B3=n338 ZN=n343
XU365 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n333 ZN=n334 A2=n332
XU364 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n330 ZN=n347 A1=n228 A3=n329 A4=n328
XU363 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n327 B1=n326 B2=n417 B3=n324 ZN=n329
XU362 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n330 A1=n323 A3=n203 A2=n322
XU361 NR4D1BWP7T $PINS VSS=VSS A4=n280 VDD=VDD ZN=n363 A3=n318 A2=n319 A1=n320
XU360 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n315 ZN=n317 A1=n316 A3=n314 A4=n313
XU359 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n316 A1=n312 A3=n310 A2=n311
XU356 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n301 ZN=n303 A1=n302 A3=n300 A4=n389
XU354 AOI22D1BWP7T $PINS B1=n346 A2=n293 ZN=n307 A1=n294 VDD=VDD B2=n292
+ VSS=VSS
XU353 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n257 ZN=n292 A1=n228 A3=n442 A4=n290
XU351 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n288 ZN=n319 A2=n287
XU348 IND4D0BWP7T $PINS VSS=VSS A1=n278 VDD=VDD B1=n445 B2=n276 B3=n275 ZN=n293
XU347 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n229 ZN=n275 A2=n273
XU344 IND4D0BWP7T $PINS VSS=VSS A1=n265 VDD=VDD B1=n264 B2=n263 B3=n155 ZN=n266
XU343 OAI211D1BWP7T $PINS A2=n260 ZN=n267 A1=n261 B=n259 VDD=VDD C=n327 VSS=VSS
XU337 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n253 ZN=n301 A2=n338
XU331 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n131 ZN=n231 A2=n41
XU329 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n222 ZN=n252 A1=n277 A3=n221 A4=n274
XU326 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n225 ZN=n217 A2=n224
XU325 NR4D0BWP7T $PINS VSS=VSS A4=n279 VDD=VDD ZN=n221 A3=n223 A2=n213 A1=n214
XU324 INVD1BWP7T $PINS ZN=n279 VSS=VSS VDD=VDD I=n212
XU315 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n190 ZN=n195 A1=n271 A3=n342 A4=n385
XU313 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n184 ZN=n185 A3=n183
XU312 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n427 ZN=n200 A1=n228 A3=n258 A4=n181
XU310 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n388 ZN=n283 A2=n175
XU307 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n300 ZN=n176 A2=n289
XU296 OAI211D1BWP7T $PINS A2=n374 ZN=n156 A1=n88 B=n184 VDD=VDD C=n154 VSS=VSS
XU295 NR4D0BWP7T $PINS VSS=VSS A4=n151 VDD=VDD ZN=n154 A3=n191 A2=n245 A1=n153
XU293 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n150 ZN=n265 A2=n230
XU291 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n149 ZN=n339 A2=n155
XU290 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n147 A2=n37 A1=n66 ZN=n149 C=n146
XU288 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n144 ZN=n320 A2=n177
XU287 NR4D0BWP7T $PINS VSS=VSS A4=n278 VDD=VDD ZN=n144 A3=n140 A2=n152 A1=n142
XU286 AOI21D0BWP7T $PINS VSS=VSS A2=n139 VDD=VDD A1=n346 B=n138 ZN=n158
XU285 AOI31D0BWP7T $PINS B=n370 ZN=n138 A1=n308 A2=n246 VDD=VDD A3=n136 VSS=VSS
XU283 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n272 ZN=n134 A1=n256 A3=n133 A4=n353
XU279 IND4D0BWP7T $PINS VSS=VSS A1=n127 VDD=VDD B1=n189 B2=n204 B3=n126 ZN=n139
XU278 NR4D0BWP7T $PINS VSS=VSS A4=n124 VDD=VDD ZN=n126 A3=n125 A2=n336 A1=n213
XU277 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n160 ZN=n125 A1=n123 A3=n173 A4=n337
XU276 INVD0BWP7T $PINS ZN=n173 VSS=VSS VDD=VDD I=n311
XU275 INVD0BWP7T $PINS ZN=n336 VSS=VSS VDD=VDD I=n352
XU272 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n203 A2=n119 A1=n131 ZN=n120 C=n358
XU270 NR4D1BWP7T $PINS VSS=VSS A4=n115 VDD=VDD ZN=n118 A3=n116 A2=n151 A1=n206
XU267 NR4D0BWP7T $PINS VSS=VSS A4=n108 VDD=VDD ZN=n110 A3=n429 A2=n335 A1=n109
XU266 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n114 ZN=n108 A1=n248 A3=n224 A4=n270
XU264 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n104 ZN=n335 A2=n328
XU263 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n239 A2=n103 A1=n356 ZN=n111
+ C=n299
XU262 AOI31D0BWP7T $PINS B=n247 ZN=n101 A1=n248 A2=n100 VDD=VDD A3=n99 VSS=VSS
XU261 NR4D0BWP7T $PINS VSS=VSS A4=n255 VDD=VDD ZN=n99 A3=n98 A2=n194 A1=n214
XU256 AOI31D1BWP7T $PINS B=n370 ZN=n102 A1=n92 A2=n165 VDD=VDD A3=n91 VSS=VSS
XU254 NR4D0BWP7T $PINS VSS=VSS A4=n89 VDD=VDD ZN=n91 A3=n90 A2=n146 A1=n229
XU253 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n263 ZN=n89 A1=n272 A3=n177 A4=n183
XU250 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n166 ZN=n206 A2=n314
XU249 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n87 ZN=n166 A2=n180
XU248 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n86 ZN=n103 A1=n189 A3=n385 A4=n259
XU247 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n132 ZN=n259 A2=n286
XU245 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n121 ZN=n83 A1=n165 A3=n82 A4=n337
XU239 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n315 A2=n141
XU234 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n72 ZN=n73 A1=n238 A3=n215 A4=n389
XU232 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n300 A1=n113 ZN=n71 A3=n388
XU231 INVD0BWP7T $PINS ZN=n94 VSS=VSS VDD=VDD I=n70
XU228 IND4D0BWP7T $PINS VSS=VSS A1=n278 VDD=VDD B1=n204 B2=n198 B3=n63 ZN=n64
XU224 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n212 ZN=n65 A1=n79 A3=n388 A4=n314
XU222 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n57 A1=n107 ZN=n58 A3=n56
XU217 NR4D0BWP7T $PINS VSS=VSS A4=n115 VDD=VDD ZN=n57 A3=n122 A2=n90 A1=n382
XU213 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n225 ZN=n151 A2=n289
XU210 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n51 A1=n162 A3=n59 A2=n214
XU209 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n388 ZN=n59 A3=n337
XU136 IND3D2BWP7T $PINS VSS=VSS VDD=VDD B1=n198 ZN=n15 A1=n169 B2=n55
XU174 AOI31D2BWP7T $PINS B=n90 A1=sin<2> ZN=n276 A2=n31 VDD=VDD A3=n13 VSS=VSS
XU106 ND3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n109 A1=n263 A2=n133 A3=n390
XU50 OAI21D2BWP7T $PINS A2=n85 A1=n131 ZN=n205 VDD=VDD B=n148 VSS=VSS
XU243 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n81 ZN=n188
XU66 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n245 A2=n143
XU165 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n180 A2=n88
XU169 INVD0BWP7T $PINS ZN=n382 VSS=VSS VDD=VDD I=n224
XU404 INVD0BWP7T $PINS ZN=n423 VSS=VSS VDD=VDD I=n424
XU265 INVD0BWP7T $PINS ZN=n421 VSS=VSS VDD=VDD I=n437
XU188 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n255 A1=n183 A2=n49 A3=n342
XU303 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n326 ZN=n389
XU109 OAI211D2BWP7T $PINS A2=n455 ZN=n254 A1=n456 B=n226 VDD=VDD C=n128 VSS=VSS
XU95 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n247 ZN=n346
XU118 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n304 A1=n10 A2=n150 A3=n313
XU320 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n202 ZN=n208 A1=n196 A3=n342 A4=n201
XU205 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n355 A1=n332 A2=n389 A3=n49
XU132 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n215 ZN=n14 A1=n113 A3=n104 A4=n196
XU257 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n161 ZN=n241
XU202 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n77 ZN=n269 A2=n88
XU142 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n375 ZN=n171 A2=n95
XU32 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<2> ZN=n295 A2=n13
XU40 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n19 ZN=n106 A2=n286
XU273 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n390 A2=n120 ZN=n127 A1=n121 A4=n287
XU301 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n165 ZN=n167 A1=n166 A3=n164 A4=n163
XU284 NR4D1BWP7T $PINS VSS=VSS A4=n134 VDD=VDD ZN=n136 A3=n135 A2=n255 A1=n180
XU102 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n155 A2=n123 ZN=n324 A1=n8 A4=n112
XU68 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n263 A2=n5 ZN=n98 A1=n205 A4=n390
XU311 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n181 A1=n180 A2=n223 A4=n283 A3=n188
XU336 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n249 A1=n242 A2=n223 A4=n351 A3=n241
XU89 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n6 A1=n75 A2=n152 A4=n60 A3=n179
XU305 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n174 A1=n172 A2=n171 A4=n169 A3=n170
XU173 OAI21D2BWP7T $PINS A2=n88 A1=n106 ZN=n90 VDD=VDD B=n202 VSS=VSS
XU133 NR4D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n198 A1=n282 A2=n203 A4=n14 A3=n350
XU168 IND4D1BWP7T $PINS VSS=VSS A1=n218 VDD=VDD B1=n333 B2=n389 ZN=n140 B3=n183
XU189 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n170 ZN=n302
XU170 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n130 A1=sin<3> ZN=n341 A3=n369
XU56 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n74 A2=n95
XU110 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n11 ZN=n84 A2=n88
XU37 OAI21D2BWP7T $PINS A2=n23 A1=n297 ZN=n146 VDD=VDD B=n160 VSS=VSS
XU238 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n226 ZN=n213
XU292 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n147 ZN=n388
XU73 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n44 ZN=n218 A2=n106
XU59 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n119 A2=n260
XU54 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n27 A2=n145
XU42 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n41 ZN=n337 A2=n85
XU8 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2 ZN=n62
XU20 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<5> ZN=n369
XU15 ND3D3BWP7T $PINS A1=sin<5> VSS=VSS VDD=VDD A3=sin<4> A2=sin<3> ZN=n30
XU401 OAI211D1BWP7T $PINS A2=n455 ZN=n419 A1=n456 B=n226 VDD=VDD C=n128 VSS=VSS
XU397 OAI211D0BWP7T $PINS A2=n29 ZN=n415 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU379 OAI211D1BWP7T $PINS A2=n29 ZN=n397 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU214 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n123 ZN=n54 A1=n196 A3=n232 A4=n271
XU366 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n337 B1=n336 B2=n335 B3=n334 ZN=n344
XU154 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n172 A2=n88
XU314 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n277 A1=n188 A2=n187 A4=n185 A3=n186
XU327 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n155 ZN=n216 A1=n215 A3=n287 A4=n175
XU330 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n225 ZN=n233 A1=n226 A3=n224 A4=n390
XU332 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n231 ZN=n349 A1=n232 A3=n230 A4=n175
XU237 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n75 ZN=n114 A2=n234
XU141 CKAN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n235 A2=n131 A1=n16
XU65 INVD1BWP7T $PINS ZN=n375 VSS=VSS VDD=VDD I=n31
XU26 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n78 A2=n1
XU297 OAI31D1BWP7T $PINS B=n356 A3=n156 ZN=n157 A2=n339 VDD=VDD A1=n320 VSS=VSS
XU321 IIND4D1BWP7T $PINS VSS=VSS A1=n206 VDD=VDD ZN=n207 B1=n205 B2=n204
+ A2=n350
XU371 IND4D1BWP7T $PINS VSS=VSS A1=n355 VDD=VDD B1=n354 B2=n353 B3=n352 ZN=n357
XU233 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n238 A1=n94 A3=n71 A2=n84
XU346 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n272 ZN=n273 A1=n315 A3=n271 A4=n270
XU184 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n215 ZN=n48 A1=n70 A3=n289 A4=n112
XU304 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n245 ZN=n390
XU355 MOAI22D0BWP7T $PINS A2=n297 A1=n374 ZN=n305 B1=n61 VSS=VSS B2=n295
+ VDD=VDD
XU53 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n147 A2=n375
XU64 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n12 A2=n192
XU34 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n16 A2=n2
XU17 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n145 ZN=n76 A2=sin<0>
XU11 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<5> ZN=n286 A2=sin<4>
XU48 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n243 A3=n446 A2=n245 A1=n162 Z=n424
XU38 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n253 A3=n254 A2=n255 A1=n335 Z=n444
XU35 AOI211XD0BWP7T $PINS A1=n37 ZN=n442 A2=n141 B=n416 VDD=VDD C=n279 VSS=VSS
XU339 AOI31D1BWP7T $PINS B=n247 ZN=n250 A1=n249 A2=n301 VDD=VDD A3=n423 VSS=VSS
XU408 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n427 I=n256
XU241 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n123 ZN=n80 A1=n79 A3=n150 A4=n128
XU306 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n174 ZN=n243 A1=n189 A3=n263 A4=n173
XU96 OAI31D1BWP7T $PINS B=n346 A3=n7 ZN=n40 A2=n98 VDD=VDD A1=n415 VSS=VSS
XU137 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n348 A2=sin<6>
XU45 ND2D1P5BWP7T $PINS VSS=VSS A2=n85 VDD=VDD A1=n16 ZN=n150
XU240 OAI211D1BWP7T $PINS VSS=VSS C=n315 VDD=VDD A2=n77 ZN=n325 A1=n78 B=n196
XU399 OAI211D1BWP7T $PINS VSS=VSS C=n315 VDD=VDD A2=n77 ZN=n417 A1=n78 B=n196
XU152 IND3D1BWP7T $PINS ZN=n318 B2=n201 B1=n20 VDD=VDD A1=n21 VSS=VSS
XU350 AOI211XD0BWP7T $PINS A1=n286 ZN=n288 A2=n130 B=n223 VDD=VDD C=n283
+ VSS=VSS
XU121 OAI211D2BWP7T $PINS VSS=VSS C=n230 VDD=VDD A2=n30 ZN=n169 A1=n145 B=n232
XU386 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n277 Z=n445
XU383 INVD0BWP7T $PINS ZN=n443 VSS=VSS VDD=VDD I=n444
XU380 INVD0BWP7T $PINS ZN=n441 VSS=VSS VDD=VDD I=n252
XU378 INVD0BWP7T $PINS ZN=n440 VSS=VSS VDD=VDD I=n441
XU376 INVD0BWP7T $PINS ZN=n439 VSS=VSS VDD=VDD I=n436
XU375 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n105 ZN=n446 A3=n106 A2=sin<2>
+ A1=sin<0>
XU349 OA31D0BWP7T $PINS Z=n437 B=n356 A3=n36 A2=n219 A1=n282 VDD=VDD VSS=VSS
XU229 OA31D0BWP7T $PINS Z=n436 B=n356 A3=n64 A2=n115 A1=n65 VDD=VDD VSS=VSS
XU259 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n227 A2=n272 ZN=n268 A1=n96 A4=n337
XU21 ND3D2BWP7T $PINS A1=sin<5> VSS=VSS VDD=VDD A3=n19 A2=sin<4> ZN=n23
XU195 INVD0BWP7T $PINS ZN=n323 VSS=VSS VDD=VDD I=n133
XU218 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n143 ZN=n234 A2=n297
XU31 INVD2BWP7T $PINS ZN=n194 VSS=VSS VDD=VDD I=n72
XU258 NR4D1BWP7T $PINS VSS=VSS A4=n152 VDD=VDD ZN=n96 A3=n282 A2=n213 A1=n94
XU317 NR4D1BWP7T $PINS VSS=VSS A4=n193 VDD=VDD ZN=n197 A3=n194 A2=n195 A1=n269
XU192 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n264 A1=n203 A2=n115 A4=n42 A3=n43
XU159 CKND0BWP7T $PINS ZN=n294 VSS=VSS VDD=VDD I=n362
XU211 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n52 ZN=n53 A1=n222 A3=n51 A4=n313
XU373 OAI211D1BWP7T $PINS A2=n362 ZN=sout<6> A1=n363 B=n361 VDD=VDD C=n360
+ VSS=VSS
XU223 OAI31D2BWP7T $PINS B=n348 A3=n58 ZN=n67 A2=n255 VDD=VDD A1=n59 VSS=VSS
XU244 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n121 A1=n147 A2=n223 A4=n188 A3=n191
XU302 NR4D1BWP7T $PINS VSS=VSS A4=n167 VDD=VDD ZN=n211 A3=n407 A2=n253 A1=n168
XU77 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n328 A1=n456 ZN=n187 A2=n455
XU166 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n326 A2=n29
XU75 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n29 ZN=n312 A2=n106
XU335 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n351 A2=n455
XU316 OAI211D1BWP7T $PINS A2=n297 ZN=n193 A1=n192 B=n388 VDD=VDD C=n390 VSS=VSS
XU282 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n302 ZN=n135 A3=n456 A2=n19 A1=n369
XU294 NR4D2BWP7T $PINS VSS=VSS A4=n265 VDD=VDD ZN=n184 A3=n241 A2=n235 A1=n172
XU246 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n114 B1=n84 B2=n219 B3=n83 ZN=n86
XU251 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n382 A2=n295 A1=n131 ZN=n92 C=n206
XU260 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n150 B1=n241 B2=n97 B3=n268 ZN=n100
XU281 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n340 A1=n172 A3=n129 A2=n171
XU333 NR4D1BWP7T $PINS VSS=VSS A4=n349 VDD=VDD ZN=n236 A3=n233 A2=n234 A1=n235
XU44 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n300 B1=n194 B2=n146 B3=n3 ZN=n4
XU186 INR2XD1BWP7T $PINS VSS=VSS VDD=VDD B1=n172 ZN=n79 A1=n225
XU206 NR4D2BWP7T $PINS VSS=VSS A4=n355 VDD=VDD ZN=n222 A3=n50 A2=n269 A1=n171
XU227 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n142 A2=n131 A1=n62 ZN=n63 C=n180
XU226 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n171 A2=n62 A1=n85 ZN=n204 C=n60
XU225 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n263 ZN=n278 A1=n128 A3=n227 A4=n352
XU82 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n261 ZN=n179 A2=n456
XU69 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n87 A2=n106
XU72 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n88 ZN=n322 A2=n455
XU177 NR4D1BWP7T $PINS VSS=VSS A4=n32 VDD=VDD ZN=n237 A3=n33 A2=n140 A1=n180
XU122 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n93 A2=n11
XU147 NR4D2BWP7T $PINS VSS=VSS A4=n186 VDD=VDD ZN=n164 A3=n170 A2=n171 A1=n235
XU271 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n263 A1=n118 ZN=n358 A3=n117
XU181 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n356 A2=n35
XU322 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n346 ZN=n209 A3=n207 A2=n320 A1=n208
XU274 NR4D1BWP7T $PINS VSS=VSS A4=n127 VDD=VDD ZN=n159 A3=n168 A2=n122 A1=n254
XU298 OAI211D1BWP7T $PINS A2=n362 ZN=sout<1> A1=n159 B=n158 VDD=VDD C=n157
+ VSS=VSS
XU345 NR4D1BWP7T $PINS VSS=VSS A4=n266 VDD=VDD ZN=n309 A3=n267 A2=n268 A1=n269
XU358 OAI211D0BWP7T $PINS A2=n18 ZN=sout<4> A1=n309 B=n307 VDD=VDD C=n298
+ VSS=VSS
XU342 AOI32D1BWP7T $PINS B2=n291 B1=n18 ZN=sout<3> A1=n258 A2=n291 VDD=VDD
+ A3=n443 VSS=VSS
XU212 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n294 ZN=n68 A3=n53 A2=n124 A1=n310
XU230 ND4D3BWP7T $PINS VSS=VSS VDD=VDD A2=n296 ZN=sout<5> A1=n182 A3=n67
+ A4=n439
XU138 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n348 ZN=n39 A3=n15 A2=n304 A1=n324
XU183 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n39 ZN=sout<7> A1=n240 A3=n137
+ A4=n421
XU269 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n113 ZN=n168 A1=n114 A3=n177 A4=n112
XU393 OR3D2BWP7T $PINS VSS=VSS A3=sin<2> VDD=VDD A2=sin<1> A1=sin<0> Z=n456
XU391 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n455 A2=n77 A1=sin<5>
XU389 AN3D2BWP7T $PINS VSS=VSS A1=n454 VDD=VDD A2=sin<3> A3=sin<5> Z=n31
XU388 INVD0BWP7T $PINS ZN=n454 VSS=VSS VDD=VDD I=sin<4>
XU387 AO211D0BWP7T $PINS Z=n453 C=n323 B=n326 A2=n61 VDD=VDD A1=n148 VSS=VSS
XU384 NR4D1BWP7T $PINS VSS=VSS A4=n21 VDD=VDD ZN=n5 A3=n74 A2=n147 A1=n452
XU382 INVD0BWP7T $PINS ZN=n452 VSS=VSS VDD=VDD I=n190
XU377 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n80 A3=n325 A2=n213 A1=n451 Z=n450
XU357 INVD0BWP7T $PINS ZN=n451 VSS=VSS VDD=VDD I=n232
XU341 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n165 I=n450
XU340 AO211D0BWP7T $PINS Z=n449 C=n176 B=n243 A2=n148 VDD=VDD A1=n178 VSS=VSS
XU338 INVD0BWP7T $PINS ZN=n258 VSS=VSS VDD=VDD I=n449
XU318 OAI211D1BWP7T $PINS VSS=VSS C=n202 VDD=VDD A2=n260 ZN=n407 A1=n143 B=n161
XU308 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n107 A1=n151 A3=n54 A2=n235
XU300 AOI31D0BWP7T $PINS B=n370 ZN=n199 A1=n445 A2=n197 VDD=VDD A3=n198 VSS=VSS
XU242 OA31D0BWP7T $PINS Z=n448 B=n105 A3=n106 A2=sin<2> A1=sin<0> VDD=VDD
+ VSS=VSS
XU236 INVD0BWP7T $PINS ZN=n429 VSS=VSS VDD=VDD I=n448
Xicc_clock3 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n137 I=n38
Xicc_clock4 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n182 I=n69
Xicc_clock5 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n244 I=n110
Xicc_clock6 NR3D1BWP7T $PINS A3=n73 VSS=VSS VDD=VDD A1=n74 A2=n142 ZN=n246
Xicc_clock7 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n248 I=n107
Xicc_clock8 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n256 A1=n87 A2=n322 A4=n187
+ A3=n218
Xicc_place23 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n333 ZN=n162
Xicc_place21 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n117 ZN=n152
Xicc_place22 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n75 ZN=n155
Xicc_place10 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n23 ZN=n61
Xicc_place20 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n297 ZN=n148
Xicc_place19 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n12 ZN=n143
Xicc_place16 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n455 ZN=n131
Xicc_place8 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n456 ZN=n41
Xicc_place11 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n261 ZN=n66
Xicc_place13 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n119 ZN=n88
Xicc_place17 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n29 ZN=n132
Xicc_place18 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n11 ZN=n141
Xicc_place3 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=sin<0> ZN=n13
Xicc_place6 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<3> ZN=n19
Xicc_place36 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n285 I=n251
Xicc_place37 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n285 A2=n440 A1=n348 ZN=n291
+ C=n250
Xicc_place38 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n296 I=n68
Xicc_place39 OA31D0BWP7T $PINS Z=n435 B=n348 A3=n303 A2=n304 A1=n305 VDD=VDD
+ VSS=VSS
Xicc_place40 INVD0BWP7T $PINS ZN=n298 VSS=VSS VDD=VDD I=n435
Xicc_place43 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n299 I=n101
Xicc_place47 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n308 I=n257
Xicc_place4 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n17 I=sin<1>
Xicc_place5 INVD0BWP7T $PINS ZN=n18 VSS=VSS VDD=VDD I=n356
Xicc_place7 INVD0BWP7T $PINS ZN=n37 VSS=VSS VDD=VDD I=n145
Xicc_place9 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n44 I=n76
Xicc_place14 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n95 I=n27
Xicc_place24 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n175 I=n179
Xicc_place25 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n177 I=n93
Xicc_place31 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n227 I=n234
Xicc_place32 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n228 I=n268
Xicc_place33 INVD0BWP7T $PINS ZN=n229 VSS=VSS VDD=VDD I=n246
Xicc_place12 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n106 ZN=n85
Xicc_place34 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n239 I=n102
Xicc_place35 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n240 I=n40
Xicc_place41 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n274 I=n220
Xicc_place42 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n280 I=n317
Xicc_place27 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n49 ZN=n191
Xicc_place26 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n453 ZN=n189
Xicc_place29 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n353 ZN=n203
Xicc_place30 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n270 ZN=n223
Xicc_place28 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n242 ZN=n196
Xicc_place44 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n93 Z=n282
.ENDS

.SUBCKT clefia_sbox1_1 sout<7> sout<6> sout<5> sout<4> sout<3> sout<2> sout<1>
+ sout<0> sin<7> sin<6> sin<5> sin<4> sin<3> sin<2> sin<1> sin<0> VSS VDD
Xicc_route_opt4 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n325 I=n174
Xicc_route_opt3 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n282 I=n429
XU73 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n85 ZN=n218 A2=n106
XU145 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n224 ZN=n170 A2=n352
XU182 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n356 ZN=n37 A3=n36 A2=n219 A1=n93
XU122 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n93 A2=n11
Xicc_place43 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n308 I=n183
XU51 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n190 A2=n143
XU47 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n77 A2=sin<4>
XU45 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n150 A2=n162
XU43 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n123 ZN=n3 A2=n337
XU42 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n227 ZN=n337 A2=n162
XU39 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n123 A2=n227
XU36 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n160 A2=n31
XU31 INVD0BWP7T $PINS ZN=n194 VSS=VSS VDD=VDD I=n72
XU30 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n153 ZN=n72 A2=n246
XU28 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n333 A2=n135
XU26 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n78 A2=n41
XU24 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n364 ZN=n260 A2=sin<1>
XU16 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=sin<1> ZN=n145 A2=sin<2>
XU14 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n300 A2=n143
XU12 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n261 A2=n286
XU8 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2 ZN=n62
XU7 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n17 ZN=n2 A2=sin<2>
XU4 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n192 A2=n132
XU3 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<5> ZN=n132
XU214 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n123 ZN=n54 A1=n203 A3=n232 A4=n271
XU213 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n225 ZN=n151 A2=n289
XU211 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n52 ZN=n53 A1=n222 A3=n51 A4=n313
XU210 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n51 A1=n246 A3=n59 A2=n214
XU209 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n387 ZN=n59 A3=n337
XU207 INVD0BWP7T $PINS ZN=n214 VSS=VSS VDD=VDD I=n105
XU204 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n196 ZN=n50 A2=n112
XU201 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n202 A1=n235 ZN=n124
XU200 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n232 ZN=n310 A2=n225
XU198 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n264 ZN=n47 A1=n79 A3=n425 A4=n105
XU197 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n135 ZN=n105 A2=n177
XU193 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<0> ZN=n45 A2=n364
XU191 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n190 ZN=n42 A2=n287
XU190 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n302 A1=n255 ZN=n43
XU189 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n170 ZN=n302
XU187 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n143 ZN=n342 A2=n61
XU185 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n95 ZN=n225 A2=n227
XU184 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n215 ZN=n48 A1=n70 A3=n289 A4=n112
XU180 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n237 ZN=n36 A1=n82 A3=n34 A4=n314
XU176 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n212 ZN=n32 A1=n276 A3=n289 A4=n313
XU175 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n74 ZN=n212 A1=n160
XU172 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n202 A2=n61
XU170 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n135 A1=sin<3> ZN=n341 A3=n132
XU164 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n82 A2=n116
XU163 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n190 ZN=n116 A2=n327
XU162 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n148 ZN=n327 A2=n27
XU161 INVD1BWP7T $PINS ZN=n219 VSS=VSS VDD=VDD I=n163
XU158 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n362 A2=sin<6>
XU157 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n52 A1=n164 ZN=n25 A3=n418
XU155 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n70 A1=n172 ZN=n122
XU153 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n22 ZN=n52 A2=n318
XU152 IND3D2BWP7T $PINS VSS=VSS VDD=VDD B1=n20 ZN=n318 A1=n21 B2=n201
XU151 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n62 ZN=n201 A2=n143
XU149 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n215 ZN=n97 A2=n81
XU148 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n81 A2=n143
XU146 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n337 ZN=n186 A2=n117
XU144 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n148 ZN=n352 A2=n227
XU143 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n224 A2=n31
XU141 CKAN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n235 A2=n177 A1=n16
XU140 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n160 A1=n203 ZN=n26 A3=n49
XU139 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n49 A2=n189
XU136 IND3D1BWP7T $PINS VSS=VSS VDD=VDD B1=n198 ZN=n15 A1=n169 B2=n55
XU135 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n55 A2=n179
XU134 INVD0BWP7T $PINS ZN=n28 VSS=VSS VDD=VDD I=n272
XU131 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n242 ZN=n203
XU130 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n85 ZN=n242 A2=n173
XU129 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n215 A2=n119
XU128 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n113 A2=n12
XU127 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n70 ZN=n350 A2=n287
XU125 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n70 A2=n148
XU124 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n353 ZN=n321
XU123 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n353 A2=n31
XU120 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n230 A2=n16
XU119 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n232 A2=n130
XU118 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n150 A1=n10 ZN=n304 A3=n313
XU117 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n10 A1=n284 A3=n22 A2=n141
XU116 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n289 A1=n9 ZN=n22 A3=n271
XU115 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n135 ZN=n271 A2=n143
XU114 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n289 A2=n177
XU113 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n183 B1=n109 B2=n411 B3=n115 ZN=n9
XU112 IND2D2BWP7T $PINS VSS=VSS VDD=VDD B1=n161 A1=n84 ZN=n115
XU111 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n161 A2=n27
XU108 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n128 A2=n177
XU107 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n143 ZN=n226 A2=n27
XU106 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n133 A1=n263 ZN=n109 A3=n223
XU105 CKND2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n183 A2=n227
XU104 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n270 ZN=n284
XU103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n270 A2=n177
XU101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n295 ZN=n112 A2=n162
XU99 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n8 A1=n246 A3=n87 A2=n142
XU98 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n332 ZN=n142
XU97 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n148 ZN=n332 A2=n61
XU94 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n247 A2=n19
XU92 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n6 ZN=n7 A1=n299 A3=n314 A4=n133
XU91 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n133 A2=n31
XU90 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n314 A2=n162
XU88 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n272 ZN=n60 A2=n313
XU87 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n313 A2=n148
XU85 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n178 ZN=n11 A2=n1
XU84 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n178 A2=n132
XU83 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n95 ZN=n272 A2=n16
XU81 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n117 ZN=n141
XU80 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n117 A2=n27
XU79 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n75 A2=n297
XU75 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n29 ZN=n312 A2=n106
XU63 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n130 ZN=n263 A2=n227
XU61 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n104 ZN=n21 A2=n163
XU60 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n163 A2=n143
XU58 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n95 ZN=n104 A2=n135
XU13 INVD0BWP7T $PINS ZN=n364 VSS=VSS VDD=VDD I=sin<2>
XU373 OAI211D0BWP7T $PINS A2=n362 ZN=sout<6> A1=n363 B=n361 VDD=VDD C=n360
+ VSS=VSS
XU372 OAI31D0BWP7T $PINS VSS=VSS VDD=VDD B=n356 ZN=n360 A3=n357 A2=n358 A1=n393
XU371 IND4D0BWP7T $PINS VSS=VSS A1=n355 VDD=VDD B1=n354 B2=n353 B3=n352 ZN=n357
XU369 AOI22D0BWP7T $PINS B1=n346 A2=n347 ZN=n361 A1=n348 VDD=VDD B2=n345
+ VSS=VSS
XU368 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n343 ZN=n345 A1=n344 A3=n342 A4=n341
XU367 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n340 B1=n358 B2=n339 B3=n338 ZN=n343
XU365 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n333 ZN=n334 A2=n332
XU364 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n330 ZN=n347 A1=n229 A3=n329 A4=n191
XU363 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n327 B1=n326 B2=n410 B3=n324 ZN=n329
XU362 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n330 A1=n323 A3=n321 A2=n322
XU361 NR4D1BWP7T $PINS VSS=VSS A4=n317 VDD=VDD ZN=n363 A3=n318 A2=n319 A1=n320
XU360 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n315 ZN=n317 A1=n316 A3=n314 A4=n313
XU359 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n316 A1=n312 A3=n310 A2=n311
XU358 OAI211D2BWP7T $PINS A2=n379 ZN=sout<4> A1=n309 B=n307 VDD=VDD C=n306
+ VSS=VSS
XU356 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n301 ZN=n303 A1=n302 A3=n300 A4=n211
XU354 AOI22D1BWP7T $PINS B1=n346 A2=n293 ZN=n307 A1=n44 VDD=VDD B2=n292 VSS=VSS
XU353 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n262 ZN=n292 A1=n229 A3=n291 A4=n290
XU352 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n289 B1=n321 B2=n355 B3=n319 ZN=n290
XU351 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n288 ZN=n319 A2=n287
XU350 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n284 A2=n135 A1=n286 ZN=n288 C=n283
XU348 IND4D1BWP7T $PINS VSS=VSS A1=n278 VDD=VDD B1=n277 B2=n276 B3=n275 ZN=n293
XU347 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n239 ZN=n275 A2=n273
XU346 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n272 ZN=n273 A1=n315 A3=n271 A4=n270
XU344 IND4D1BWP7T $PINS VSS=VSS A1=n265 VDD=VDD B1=n264 B2=n263 B3=n155 ZN=n266
XU341 NR4D1BWP7T $PINS VSS=VSS A4=n253 VDD=VDD ZN=n256 A3=n254 A2=n255 A1=n335
XU339 AOI31D1BWP7T $PINS B=n247 ZN=n250 A1=n182 A2=n301 VDD=VDD A3=n248 VSS=VSS
XU335 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n351 A2=n441
XU331 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n177 ZN=n231 A2=n227
XU330 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n225 ZN=n233 A1=n226 A3=n224 A4=n223
XU329 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n222 ZN=n252 A1=n277 A3=n221 A4=n220
XU327 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n155 ZN=n216 A1=n215 A3=n287 A4=n383
XU326 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n225 ZN=n217 A2=n224
XU325 NR4D0BWP7T $PINS VSS=VSS A4=n279 VDD=VDD ZN=n221 A3=n284 A2=n213 A1=n214
XU324 INVD0BWP7T $PINS ZN=n279 VSS=VSS VDD=VDD I=n212
XU323 OAI211D0BWP7T $PINS A2=n379 ZN=sout<2> A1=n296 B=n210 VDD=VDD C=n209
+ VSS=VSS
XU321 IIND4D1BWP7T $PINS VSS=VSS A1=n206 VDD=VDD ZN=n207 B1=n205 B2=n204
+ A2=n350
XU320 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n202 ZN=n208 A1=n203 A3=n342 A4=n201
XU319 AOI21D0BWP7T $PINS VSS=VSS A2=n200 VDD=VDD A1=n44 B=n199 ZN=n210
XU318 AOI31D1BWP7T $PINS B=n46 ZN=n199 A1=n277 A2=n198 VDD=VDD A3=n298 VSS=VSS
XU315 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n190 ZN=n195 A1=n271 A3=n342 A4=n381
XU313 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n184 ZN=n185 A3=n308
XU312 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n299 ZN=n200 A1=n229 A3=n258 A4=n181
XU311 NR4D1BWP7T $PINS VSS=VSS A4=n283 VDD=VDD ZN=n181 A3=n188 A2=n284 A1=n180
XU310 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n387 ZN=n283 A2=n383
XU307 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n300 ZN=n176 A2=n289
XU301 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n165 ZN=n167 A1=n166 A3=n164 A4=n163
XU298 OAI211D1BWP7T $PINS A2=n362 ZN=sout<1> A1=n159 B=n158 VDD=VDD C=n157
+ VSS=VSS
XU293 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n150 ZN=n265 A2=n230
XU291 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n149 ZN=n339 A2=n155
XU288 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n144 ZN=n320 A2=n196
XU286 AOI21D0BWP7T $PINS VSS=VSS A2=n139 VDD=VDD A1=n346 B=n138 ZN=n158
XU285 AOI31D0BWP7T $PINS B=n46 ZN=n138 A1=n262 A2=n137 VDD=VDD A3=n136 VSS=VSS
XU284 NR4D1BWP7T $PINS VSS=VSS A4=n134 VDD=VDD ZN=n136 A3=n427 A2=n255 A1=n180
XU283 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n272 ZN=n134 A1=n299 A3=n133 A4=n353
XU280 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n128 ZN=n129 A1=n205 A3=n230 A4=n313
XU279 IND4D0BWP7T $PINS VSS=VSS A1=n127 VDD=VDD B1=n175 B2=n204 B3=n126 ZN=n139
XU278 NR4D0BWP7T $PINS VSS=VSS A4=n124 VDD=VDD ZN=n126 A3=n125 A2=n336 A1=n213
XU277 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n160 ZN=n125 A1=n123 A3=n384 A4=n337
XU275 INVD0BWP7T $PINS ZN=n336 VSS=VSS VDD=VDD I=n352
XU272 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n321 A2=n119 A1=n177 ZN=n120 C=n358
XU270 NR4D0BWP7T $PINS VSS=VSS A4=n115 VDD=VDD ZN=n118 A3=n116 A2=n151 A1=n206
XU269 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n113 ZN=n168 A1=n114 A3=n196 A4=n112
XU266 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n114 ZN=n108 A1=n281 A3=n224 A4=n270
XU264 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n104 ZN=n335 A2=n191
XU263 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n102 A2=n103 A1=n356 ZN=n111
+ C=n294
XU262 AOI31D0BWP7T $PINS B=n247 ZN=n101 A1=n281 A2=n100 VDD=VDD A3=n99 VSS=VSS
XU261 NR4D0BWP7T $PINS VSS=VSS A4=n255 VDD=VDD ZN=n99 A3=n98 A2=n194 A1=n214
XU257 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n161 ZN=n241
XU254 NR4D1BWP7T $PINS VSS=VSS A4=n89 VDD=VDD ZN=n91 A3=n90 A2=n146 A1=n239
XU253 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n263 ZN=n89 A1=n272 A3=n196 A4=n308
XU251 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n88 A2=n295 A1=n177 ZN=n92 C=n206
XU250 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n166 ZN=n206 A2=n314
XU249 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n87 ZN=n166 A2=n180
XU248 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n285 ZN=n103 A1=n175 A3=n381 A4=n259
XU247 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n189 ZN=n259 A2=n286
XU245 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n121 ZN=n83 A1=n165 A3=n82 A4=n337
XU243 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n81 ZN=n188
XU239 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n76 ZN=n315 A2=n148
XU237 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n75 ZN=n114 A2=n234
XU234 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n72 ZN=n73 A1=n238 A3=n215 A4=n211
XU233 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n238 A1=n94 A3=n71 A2=n84
XU232 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n300 A1=n113 ZN=n71 A3=n387
XU231 INVD0BWP7T $PINS ZN=n94 VSS=VSS VDD=VDD I=n70
XU228 IND4D0BWP7T $PINS VSS=VSS A1=n278 VDD=VDD B1=n204 B2=n198 B3=n63 ZN=n64
XU227 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n142 A2=n177 A1=n62 ZN=n63 C=n180
XU224 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n212 ZN=n65 A1=n79 A3=n387 A4=n314
XU222 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n57 A1=n281 ZN=n58 A3=n56
XU221 NR4D0BWP7T $PINS VSS=VSS A4=n338 VDD=VDD ZN=n56 A3=n116 A2=n321 A1=n142
XU217 NR4D0BWP7T $PINS VSS=VSS A4=n115 VDD=VDD ZN=n57 A3=n122 A2=n90 A1=n88
XU216 INVD0BWP7T $PINS ZN=n88 VSS=VSS VDD=VDD I=n224
XU338 NR4D0BWP7T $PINS VSS=VSS A4=n243 VDD=VDD ZN=n248 A3=n244 A2=n245 A1=n246
XU336 NR4D0BWP7T $PINS VSS=VSS A4=n351 VDD=VDD ZN=n249 A3=n241 A2=n284 A1=n242
XU370 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n350 A2=n351 A1=sin<1> ZN=n354
+ C=n349
XU377 OAI211D0BWP7T $PINS A2=n29 ZN=n393 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU150 AOI31D1BWP7T $PINS B=n97 ZN=n20 A1=sin<0> A2=n130 VDD=VDD A3=n17 VSS=VSS
XU202 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n77 ZN=n269 A2=n131
XU287 NR4D0BWP7T $PINS VSS=VSS A4=n278 VDD=VDD ZN=n144 A3=n140 A2=n141 A1=n142
XU317 NR4D0BWP7T $PINS VSS=VSS A4=n193 VDD=VDD ZN=n197 A3=n194 A2=n195 A1=n269
XU273 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n120 ZN=n127 A1=n121 A3=n223 A4=n287
XU295 NR4D1BWP7T $PINS VSS=VSS A4=n151 VDD=VDD ZN=n154 A3=n152 A2=n245 A1=n153
XU297 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n356 ZN=n157 A3=n156 A2=n339 A1=n320
XU89 NR4D1BWP7T $PINS VSS=VSS A4=n60 VDD=VDD ZN=n6 A3=n179 A2=n141 A1=n75
XU179 NR4D1BWP7T $PINS VSS=VSS A4=n322 VDD=VDD ZN=n34 A3=n152 A2=n87 A1=n242
XU137 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n348 A2=sin<6>
XU267 NR4D1BWP7T $PINS VSS=VSS A4=n108 VDD=VDD ZN=n110 A3=n244 A2=n335 A1=n109
XU268 AOI32D2BWP7T $PINS B2=n111 B1=n362 ZN=sout<0> A1=n137 A2=n111 VDD=VDD
+ A3=n110 VSS=VSS
XU342 AOI32D0BWP7T $PINS B2=n257 B1=n379 ZN=sout<3> A1=n258 A2=n257 VDD=VDD
+ A3=n256 VSS=VSS
XU62 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n190 B1=n147 B2=n74 B3=n21 ZN=n5
XU171 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n381 A1=n81 ZN=n33 A3=n341
XU168 IND4D2BWP7T $PINS VSS=VSS A1=n218 VDD=VDD B1=n333 B2=n211 ZN=n140 B3=n308
XU29 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n333 ZN=n246
XU402 INVD0BWP7T $PINS ZN=n418 VSS=VSS VDD=VDD I=n428
XU206 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n222 A1=n171 A2=n269 A4=n355 A3=n50
XU33 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n295 ZN=n297 A2=n17
XU132 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n104 A2=n215 ZN=n14 A1=n113 A4=n203
XU316 OAI211D1BWP7T $PINS A2=n297 ZN=n193 A1=n192 B=n387 VDD=VDD C=n223 VSS=VSS
XU195 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n133 ZN=n323
XU40 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1 ZN=n106 A2=n286
XU345 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n309 A1=n269 A2=n268 A4=n266 A3=n403
XU133 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n198 A1=n93 A2=n321 A4=n14 A3=n350
XU44 INR4D1BWP7T $PINS ZN=n4 A1=n300 B3=n3 B2=n146 VDD=VDD B1=n194 VSS=VSS
XU244 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n121 A1=n147 A2=n284 A4=n188 A3=n152
XU147 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n164 A1=n235 A2=n171 A4=n186 A3=n170
XU294 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n184 A1=n172 A2=n235 A4=n265 A3=n241
XU225 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n228 A2=n263 ZN=n278 A1=n128 A4=n352
XU332 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n230 A2=n231 ZN=n349 A1=n232 A4=n383
XU188 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n255 A1=n308 A2=n49 A3=n342
XU238 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n226 ZN=n213
XU50 OAI21D1BWP7T $PINS B=n61 A2=n162 ZN=n205 VDD=VDD A1=n177 VSS=VSS
XU173 OAI21D2BWP7T $PINS A2=n131 A1=n106 ZN=n90 VDD=VDD B=n202 VSS=VSS
XU355 IOA22D2BWP7T $PINS A2=n295 ZN=n305 A1=n130 B2=n297 VDD=VDD B1=n372
+ VSS=VSS
XU110 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n11 ZN=n84 A2=n131
XU69 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n87 A2=n106
XU19 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n153 A2=n85
XU154 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n172 A2=n131
XU95 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n247 ZN=n346
XU11 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<5> ZN=n286 A2=sin<4>
XU59 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n119 A2=n260
XU32 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<2> ZN=n295 A2=n13
XU54 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n27 A2=n145
XU395 OAI211D1BWP7T $PINS A2=n441 ZN=n411 A1=n18 B=n226 VDD=VDD C=n128 VSS=VSS
XU393 OAI211D1BWP7T $PINS A2=n29 ZN=n409 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU328 NR4D1BWP7T $PINS VSS=VSS A4=n216 VDD=VDD ZN=n220 A3=n217 A2=n218 A1=n219
XU230 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n68 ZN=sout<5> A1=n69 A3=n67 A4=n66
XU205 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n211 A1=n332 ZN=n355 A3=n49
XU258 NR4D1BWP7T $PINS VSS=VSS A4=n141 VDD=VDD ZN=n96 A3=n93 A2=n213 A1=n94
XU305 NR4D1BWP7T $PINS VSS=VSS A4=n169 VDD=VDD ZN=n174 A3=n170 A2=n171 A1=n172
XU303 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n147 ZN=n387
XU53 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n147 A2=n366
XU126 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n287 A2=n16
XU52 CKND0BWP7T $PINS ZN=n369 VSS=VSS VDD=VDD I=n27
XU199 OAI31D1BWP7T $PINS B=n346 A3=n47 ZN=n69 A2=n359 VDD=VDD A1=n48 VSS=VSS
XU223 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n348 ZN=n67 A3=n58 A2=n255 A1=n59
XU322 OAI31D1BWP7T $PINS B=n346 A3=n267 ZN=n209 A2=n320 VDD=VDD A1=n208 VSS=VSS
XU271 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n358 A1=n118 A2=n263 A3=n117
XU366 INR4D1BWP7T $PINS ZN=n344 A1=n337 B3=n334 B2=n335 VDD=VDD B1=n336 VSS=VSS
XU259 ND4D3BWP7T $PINS VSS=VSS VDD=VDD A3=n228 A2=n272 ZN=n268 A1=n96 A4=n337
XU82 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n261 ZN=n179 A2=n18
XU64 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n12 A2=n192
XU17 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n145 ZN=n76 A2=sin<0>
XU181 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n356 A2=n19
XU255 INVD0BWP7T $PINS ZN=n384 VSS=VSS VDD=VDD I=n311
XU203 INVD0BWP7T $PINS ZN=n381 VSS=VSS VDD=VDD I=n171
XU167 INVD0BWP7T $PINS ZN=n379 VSS=VSS VDD=VDD I=n356
XU65 INVD0BWP7T $PINS ZN=n372 VSS=VSS VDD=VDD I=n286
XU384 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n441 A2=n77 A1=sin<5>
XU382 AN3D2BWP7T $PINS VSS=VSS A1=sin<5> VDD=VDD A2=sin<3> A3=n35 Z=n31
XU381 OA31D0BWP7T $PINS Z=n440 B=n105 A3=n106 A2=sin<2> A1=sin<0> VDD=VDD
+ VSS=VSS
XU380 AO211D0BWP7T $PINS Z=n439 C=n323 B=n326 A2=n130 VDD=VDD A1=n61 VSS=VSS
XU378 INVD0BWP7T $PINS ZN=n175 VSS=VSS VDD=VDD I=n439
XU376 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n244 I=n440
XU375 OAI211D1BWP7T $PINS VSS=VSS C=n161 VDD=VDD A2=n260 ZN=n407 A1=n173 B=n202
XU343 AO211D0BWP7T $PINS Z=n436 C=n60 B=n171 A2=n62 VDD=VDD A1=n162 VSS=VSS
XU340 INVD0BWP7T $PINS ZN=n204 VSS=VSS VDD=VDD I=n436
XU337 AOI31D1BWP7T $PINS B=n362 ZN=n251 A1=n237 A2=n236 VDD=VDD A3=n238 VSS=VSS
XU334 AO211D0BWP7T $PINS Z=n435 C=n176 B=n243 A2=n61 VDD=VDD A1=n178 VSS=VSS
XU309 INVD0BWP7T $PINS ZN=n258 VSS=VSS VDD=VDD I=n435
XU308 OAI211D1BWP7T $PINS VSS=VSS C=n327 VDD=VDD A2=n260 ZN=n403 A1=n261 B=n259
XU306 AOI31D1BWP7T $PINS B=n46 ZN=n102 A1=n91 A2=n92 VDD=VDD A3=n165 VSS=VSS
XU299 AN4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n39 A3=n38 A4=n107 Z=sout<7> A1=n40
XU265 IND4D1BWP7T $PINS VSS=VSS A1=n439 VDD=VDD B1=n325 B2=n263 ZN=n243 B3=n384
XU256 AN4D1BWP7T $PINS VSS=VSS A1=n232 VDD=VDD A2=n226 A3=n438 A4=n240 Z=n165
XU236 AN2D2BWP7T $PINS VSS=VSS A1=n119 VDD=VDD A2=n177 Z=n322
XU235 INR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n225 ZN=n79 B1=n172
XU226 OA211D0BWP7T $PINS VSS=VSS C=n315 VDD=VDD B=n203 A2=n77 A1=n78 Z=n438
XU220 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n190 ZN=n253 A1=n287 A3=n160 A4=n314
XU186 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n228 ZN=n338 A1=n163 A3=n113 A4=n55
XU183 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD ZN=n301 A1=n253 A2=n338
XU72 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n137 A1=n73 A3=n142 A2=n74
XU35 NR4D1BWP7T $PINS VSS=VSS A4=n167 VDD=VDD ZN=n429 A3=n253 A2=n280 A1=n168
XU138 OAI31D1BWP7T $PINS B=n348 A3=n15 ZN=n39 A2=n304 VDD=VDD A1=n324 VSS=VSS
XU96 OAI31D1BWP7T $PINS B=n346 A3=n7 ZN=n40 A2=n98 VDD=VDD A1=n409 VSS=VSS
XU160 OAI31D2BWP7T $PINS ZN=n38 A3=n80 A2=n26 A1=n153 B=n44 VDD=VDD VSS=VSS
XU102 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n155 A2=n123 ZN=n324 A1=n8 A4=n112
XU109 OAI211D2BWP7T $PINS ZN=n254 A2=n441 A1=n18 C=n128 VDD=VDD B=n226 VSS=VSS
XU300 OAI211D1BWP7T $PINS ZN=n280 A2=n260 A1=n173 C=n161 VDD=VDD B=n202 VSS=VSS
XU296 OAI211D1BWP7T $PINS VSS=VSS C=n154 VDD=VDD A2=n372 ZN=n156 A1=n131 B=n184
XU333 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n236 A1=n235 A2=n234 A4=n349 A3=n233
XU394 OAI211D1BWP7T $PINS VSS=VSS C=n315 VDD=VDD A2=n77 ZN=n410 A1=n78 B=n203
XU121 OAI211D2BWP7T $PINS ZN=n169 A2=n30 A1=n145 C=n230 VDD=VDD B=n232 VSS=VSS
XU302 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n122 A3=n179 A2=n322 A1=n312 Z=n428
XU196 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n311 A2=n45 A1=n148 ZN=n425 C=n323
XU156 OAI31D1BWP7T $PINS B=n302 A3=n18 ZN=n427 A2=n1 VDD=VDD A1=n132 VSS=VSS
XU68 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n5 ZN=n98 A1=n205 A3=n263 A4=n223
XU177 NR4D1BWP7T $PINS VSS=VSS A4=n32 VDD=VDD ZN=n237 A3=n33 A2=n140 A1=n180
XU194 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n297 ZN=n311 A2=n441
XU166 NR2D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n326 A1=n30 A2=n29
XU34 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n16 A2=n2
XU15 ND3D3BWP7T $PINS A1=sin<5> VSS=VSS VDD=VDD A3=sin<4> A2=sin<3> ZN=n30
XU21 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n23 A1=sin<5> A2=sin<4> A3=n1
XU9 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n29 A2=n62
XU38 NR3D3BWP7T $PINS A3=sin<2> VSS=VSS VDD=VDD A1=sin<0> A2=sin<1> ZN=n227
XU22 INVD0BWP7T $PINS ZN=n366 VSS=VSS VDD=VDD I=n31
XU165 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n30 A2=n131 ZN=n180
XU66 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n78 ZN=n245 A2=n173
XU218 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n173 ZN=n234 A2=n297
XU252 INVD1BWP7T $PINS ZN=n383 VSS=VSS VDD=VDD I=n179
XU142 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n366 A2=n369 ZN=n171
XU290 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n147 A2=n24 A1=n143 ZN=n149 C=n146
XU178 INVD1BWP7T $PINS ZN=n152 VSS=VSS VDD=VDD I=n49
XU314 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n277 A1=n188 A2=n187 A4=n185 A3=n186
XU274 NR4D1BWP7T $PINS VSS=VSS A4=n127 VDD=VDD ZN=n159 A3=n168 A2=n122 A1=n254
XU357 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n348 ZN=n306 A3=n303 A2=n304 A1=n305
XU246 INR4D0BWP7T $PINS ZN=n86 A1=n114 B3=n83 B2=n219 VDD=VDD B1=n84 VSS=VSS
XU37 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n160 A1=n297 ZN=n146 A2=n23
XU77 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n191 A1=n18 ZN=n187 A2=n441
XU192 NR4D1BWP7T $PINS VSS=VSS A4=n42 VDD=VDD ZN=n264 A3=n43 A2=n115 A1=n321
XU174 AOI31D2BWP7T $PINS B=n90 ZN=n276 A1=sin<2> A2=n31 VDD=VDD A3=n13 VSS=VSS
XU349 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n407 A2=n148 A1=n24 ZN=n291 C=n279
XU281 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n340 A1=n172 A3=n129 A2=n171
XU260 INR4D2BWP7T $PINS VSS=VSS VDD=VDD A1=n150 B1=n241 B2=n97 B3=n268 ZN=n100
XU56 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n74 A2=n369
XU46 OAI211D1BWP7T $PINS A2=n29 ZN=n359 A1=n192 B=n4 VDD=VDD C=n150 VSS=VSS
XU212 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n44 ZN=n68 A3=n53 A2=n124 A1=n310
XU229 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n356 ZN=n66 A3=n64 A2=n115 A1=n65
Xicc_clock3 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n80 I=n25
Xicc_clock4 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n107 I=n37
Xicc_clock5 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n182 I=n249
Xicc_clock6 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n262 I=n340
Xicc_place7 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n19 I=sin<7>
Xicc_place8 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n24 I=n145
Xicc_place9 INVD0BWP7T $PINS ZN=n35 VSS=VSS VDD=VDD I=sin<4>
Xicc_place10 INVD0BWP7T $PINS ZN=n41 VSS=VSS VDD=VDD I=n260
Xicc_place12 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n46 I=n348
Xicc_place14 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n85 I=n76
Xicc_place15 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n95 I=n30
Xicc_place27 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n196 I=n93
Xicc_place29 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n223 I=n245
Xicc_place30 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n228 I=n234
Xicc_place31 INVD0BWP7T $PINS ZN=n229 VSS=VSS VDD=VDD I=n268
Xicc_place32 INVD0BWP7T $PINS ZN=n239 VSS=VSS VDD=VDD I=n137
Xicc_place33 AN4D1BWP7T $PINS VSS=VSS A1=n79 VDD=VDD A2=n123 A3=n150 A4=n128
+ Z=n240
Xicc_place34 AOI211XD0BWP7T $PINS A1=n348 ZN=n257 A2=n252 B=n274 VDD=VDD C=n250
+ VSS=VSS
Xicc_place36 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n267 I=n207
Xicc_place37 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n274 I=n251
Xicc_place38 NR3D1BWP7T $PINS A3=n54 VSS=VSS VDD=VDD A1=n235 A2=n151 ZN=n281
Xicc_place11 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n362 ZN=n44
Xicc_place21 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n75 ZN=n155
Xicc_place26 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n312 ZN=n191
Xicc_place28 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n326 ZN=n211
Xicc_place25 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n29 ZN=n189
Xicc_place6 INVD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n227 ZN=n18
Xicc_place16 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n23 ZN=n130
Xicc_place22 CKND8BWP7T $PINS VDD=VDD VSS=VSS I=n106 ZN=n162
Xicc_place19 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n261 ZN=n143
Xicc_place23 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n12 ZN=n173
Xicc_place24 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n441 ZN=n177
Xicc_place13 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n297 ZN=n61
Xicc_place18 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n78 ZN=n135
Xicc_place20 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n11 ZN=n148
Xicc_place17 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n119 ZN=n131
Xicc_place3 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<3> ZN=n1
Xicc_place4 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=sin<0> ZN=n13
Xicc_place5 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<1> ZN=n17
Xicc_place35 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n285 I=n86
Xicc_place39 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n294 I=n101
Xicc_place40 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n296 I=n282
Xicc_place41 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n298 I=n197
Xicc_place42 NR4D2BWP7T $PINS VSS=VSS VDD=VDD A4=n187 A3=n218 A2=n322 ZN=n299
+ A1=n87
.ENDS

.SUBCKT clefia_sbox1_2 sout<7> sout<6> sout<5> sout<4> sout<3> sout<2> sout<1>
+ sout<0> sin<7> sin<6> sin<5> sin<4> sin<3> sin<2> sin<1> sin<0> VDD VSS
Xicc_route_opt5 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n340 Z=n246
Xicc_route_opt4 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n237 I=n34
Xicc_route_opt3 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n234 I=n174
XU142 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n337 A2=n450 A1=n72
XU304 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n129 ZN=n170 A1=n262 A3=n239 A4=n380
XU73 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n70 ZN=n172 A2=n72
XU133 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n438 ZN=n168
XU159 INVD2BWP7T $PINS ZN=n279 VSS=VSS VDD=VDD I=n362
XU371 IND4D1BWP7T $PINS VSS=VSS A1=n355 VDD=VDD B1=n354 B2=n353 B3=n352 ZN=n357
XU216 AOI31D1BWP7T $PINS B=n374 A1=n59 ZN=n69 A2=n122 VDD=VDD A3=n58 VSS=VSS
XU111 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n119 A2=n27
XU108 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n100 A2=n38
XU107 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n178 A2=n27
XU106 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n93 A1=n218 ZN=n74 A3=n381
XU105 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n138 A2=n54
XU104 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n224 ZN=n236
XU103 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n224 A2=n38
XU101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n245 ZN=n260 A2=n35
XU99 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n8 A1=n275 A3=n56 A2=n296
XU98 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n332 ZN=n296
XU97 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n18 ZN=n332 A2=n107
XU94 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n200 A2=n40
XU91 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n46 ZN=n93 A2=n31
XU90 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n27 ZN=n314 A2=n35
XU88 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n226 ZN=n83 A2=n313
XU87 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n313 A2=n18
XU85 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n134 ZN=n11 A2=n12
XU84 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n134 A2=n92
XU83 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n366 ZN=n226 A2=n16
XU81 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n78 ZN=n102
XU80 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n78 A2=n27
XU63 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n218 A2=n54
XU61 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n71 ZN=n21 A2=n193
XU60 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n232 ZN=n193 A2=n28
XU58 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n366 ZN=n71 A2=n90
XU51 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n214 A2=n28
XU47 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n145 A2=sin<4>
XU43 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n85 ZN=n3 A2=n337
XU39 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n85 A2=n54
XU36 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n118 A2=n31
XU31 INVD0BWP7T $PINS ZN=n149 VSS=VSS VDD=VDD I=n42
XU30 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n112 ZN=n42 A2=n275
XU29 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n333 ZN=n275
XU28 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n333 A2=n90
XU25 INVD0BWP7T $PINS ZN=n1 VSS=VSS VDD=VDD I=n212
XU24 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n264 ZN=n212 A2=sin<1>
XU23 INVD0BWP7T $PINS ZN=n264 VSS=VSS VDD=VDD I=sin<2>
XU14 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n250 A2=n28
XU12 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<3> ZN=n213 A2=n238
XU9 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n48 ZN=n29 A2=n298
XU8 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2 ZN=n298
XU7 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n19 ZN=n2 A2=sin<2>
XU4 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<4> ZN=n147 A2=n92
XU3 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sin<5> ZN=n92
XU291 NR4D1BWP7T $PINS VSS=VSS A4=n148 VDD=VDD ZN=n152 A3=n149 A2=n150 A1=n223
XU290 OAI211D1BWP7T $PINS A2=n247 ZN=n148 A1=n147 B=n382 VDD=VDD C=n381 VSS=VSS
XU289 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n214 ZN=n150 A1=n225 A3=n342 A4=n438
XU286 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n139 ZN=n140 A3=n138
XU285 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n137 ZN=n154 A1=n442 A3=n210 A4=n136
XU283 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n382 ZN=n235 A2=n380
XU280 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n250 ZN=n132 A2=n261
XU271 OAI211D1BWP7T $PINS A2=n362 ZN=sout<1> A1=n117 B=n116 VDD=VDD C=n115
+ VSS=VSS
XU266 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n109 ZN=n219 A2=n181
XU264 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n108 ZN=n339 A2=n129
XU263 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n106 A2=n17 A1=n28 ZN=n108 C=n105
XU261 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n103 ZN=n320 A2=n378
XU260 NR4D1BWP7T $PINS VSS=VSS A4=n302 VDD=VDD ZN=n103 A3=n101 A2=n102 A1=n296
XU258 AOI21D0BWP7T $PINS VSS=VSS A2=n99 VDD=VDD A1=n346 B=n189 ZN=n116
XU257 AOI31D0BWP7T $PINS B=n374 ZN=n98 A1=n246 A2=n97 VDD=VDD A3=n96 VSS=VSS
XU255 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n226 ZN=n94 A1=n137 A3=n93 A4=n353
XU251 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n100 ZN=n89 A1=n158 A3=n181 A4=n313
XU250 IND4D0BWP7T $PINS VSS=VSS A1=n88 VDD=VDD B1=n131 B2=n179 B3=n87 ZN=n99
XU248 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n156 A1=n185 ZN=n281
XU247 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n118 ZN=n86 A1=n85 A3=n120 A4=n337
XU244 INVD0BWP7T $PINS ZN=n336 VSS=VSS VDD=VDD I=n352
XU242 NR4D1BWP7T $PINS VSS=VSS A4=n88 VDD=VDD ZN=n117 A3=n125 A2=n282 A1=n419
XU240 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n321 A2=n232 A1=n38 ZN=n81 C=n358
XU236 AOI32D1BWP7T $PINS B2=n76 B1=n362 ZN=sout<0> A1=n97 A2=n37 VDD=VDD A3=n75
+ VSS=VSS
XU232 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n71 ZN=n335 A2=n328
XU231 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n69 A2=n394 A1=n228 ZN=n76 C=n68
XU230 AOI31D0BWP7T $PINS B=n200 ZN=n68 A1=n288 A2=n67 VDD=VDD A3=n66 VSS=VSS
XU229 NR4D0BWP7T $PINS VSS=VSS A4=n290 VDD=VDD ZN=n66 A3=n65 A2=n149 A1=n274
XU227 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n28 ZN=n342 A2=n107
XU226 INVD0BWP7T $PINS ZN=n274 VSS=VSS VDD=VDD I=n267
XU225 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n90 ZN=n267 A2=n38
XU222 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n184 ZN=n194
XU218 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n85 ZN=n60 A1=n157 A3=n273 A4=n225
XU217 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n272 ZN=n110 A2=n261
XU214 NR4D0BWP7T $PINS VSS=VSS A4=n57 VDD=VDD ZN=n58 A3=n283 A2=n105 A1=n390
XU213 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n218 ZN=n57 A1=n226 A3=n378 A4=n138
XU209 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n123 ZN=n159 A2=n314
XU208 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n56 ZN=n123 A2=n295
XU207 INVD0BWP7T $PINS ZN=n284 VSS=VSS VDD=VDD I=n177
XU205 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n211 A2=n238
XU203 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n82 ZN=n52 A1=n122 A3=n51 A4=n337
XU201 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n50 ZN=n143
XU197 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n366 ZN=n272 A2=n54
XU195 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n46 ZN=n315 A2=n18
XU193 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n45 ZN=n77 A2=n184
XU190 INVD0BWP7T $PINS ZN=n323 VSS=VSS VDD=VDD I=n93
XU188 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n42 ZN=n43 A1=n188 A3=n262 A4=n385
XU186 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n250 A1=n195 ZN=n41 A3=n382
XU184 INVD0BWP7T $PINS ZN=n62 VSS=VSS VDD=VDD I=n263
XU180 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n187 ZN=n36 A1=n51 A3=n217 A4=n314
XU178 INVD0BWP7T $PINS ZN=n111 VSS=VSS VDD=VDD I=n166
XU176 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n293 ZN=n32 A1=n230 A3=n261 A4=n313
XU172 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n31 ZN=n156 A2=n107
XU171 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n438 A1=n50 ZN=n33 A3=n341
XU170 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n90 A1=sin<3> ZN=n341 A3=n92
XU164 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n379 ZN=n51 A2=n285
XU163 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n214 ZN=n285 A2=n327
XU162 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n18 ZN=n327 A2=n27
XU161 INVD1BWP7T $PINS ZN=n173 VSS=VSS VDD=VDD I=n193
XU158 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n362 A2=sin<6>
XU157 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n277 A1=n121 ZN=n25 A3=n24
XU155 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n263 A1=n128 ZN=n282
XU153 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n22 ZN=n277 A2=n318
XU152 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n20 ZN=n318 A1=n21 B2=n155
XU151 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n298 ZN=n155 A2=n28
XU150 AOI31D1BWP7T $PINS B=n64 ZN=n20 A1=sin<0> A2=n13 VDD=VDD A3=n19 VSS=VSS
XU149 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n262 ZN=n64 A2=n50
XU148 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n46 ZN=n50 A2=n28
XU146 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n337 ZN=n141 A2=n78
XU145 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n177 ZN=n127 A2=n352
XU144 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n18 ZN=n352 A2=n54
XU143 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n232 ZN=n177 A2=n31
XU140 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n118 A1=n157 ZN=n26 A3=n166
XU139 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n166 A2=n84
XU135 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n379 ZN=n196 A2=n135
XU130 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n70 ZN=n192 A2=n439
XU129 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n262 A2=n232
XU128 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n195 A2=n39
XU127 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n263 ZN=n350 A2=n239
XU126 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n239 A2=n16
XU125 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n263 A2=n18
XU124 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n353 ZN=n321
XU123 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n84 ZN=n353 A2=n31
XU120 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n13 ZN=n181 A2=n16
XU119 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n46 ZN=n273 A2=n13
XU118 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n109 A1=n10 ZN=n254 A3=n313
XU117 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n10 A1=n236 A3=n22 A2=n102
XU116 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n261 A1=n9 ZN=n22 A3=n225
XU115 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n90 ZN=n225 A2=n28
XU114 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n46 ZN=n261 A2=n38
XU113 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n138 B1=n74 B2=n207 B3=n304 ZN=n9
XU112 IND2D2BWP7T $PINS VSS=VSS VDD=VDD B1=n119 A1=n53 ZN=n304
XU181 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<6> ZN=n356 A2=n40
XU141 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n185 A2=n38 A1=n16
XU348 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n277 ZN=n280 A1=n278 A3=n276 A4=n313
XU307 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n272 ZN=n183 A1=n178 A3=n177 A4=n381
XU192 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n439 ZN=n184 A2=n247
XU220 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n119 ZN=n191
XU312 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n48 ZN=n351 A2=n449
XU26 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n48 ZN=n47 A2=n1
XU10 INVD0BWP7T $PINS ZN=n364 VSS=VSS VDD=VDD I=n31
XU189 NR3D1BWP7T $PINS A3=n43 VSS=VSS VDD=VDD A1=n44 A2=n296 ZN=n97
XU239 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n358 A1=n79 A2=n218 A3=n78
XU360 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n315 ZN=n317 A1=n316 A3=n314 A4=n313
XU279 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n218 A2=n130 ZN=n197 A1=n131 A4=n120
XU336 MOAI22D1BWP7T $PINS A2=n247 A1=n367 ZN=n255 B1=n13 VSS=VSS B2=n245
+ VDD=VDD
XU245 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n247 ZN=n311 A2=n449
XU79 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n45 A2=n247
XU154 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n128 A2=n91
XU185 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n199 ZN=n381
XU211 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n106 ZN=n382
XU53 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n47 ZN=n106 A2=n364
XU59 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n48 ZN=n80 A2=n212
XU137 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<7> ZN=n348 A2=sin<6>
XU54 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n48 ZN=n27 A2=n104
XU17 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n104 ZN=n46 A2=sin<0>
XU11 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<5> ZN=n238 A2=sin<4>
XU301 INVD0BWP7T $PINS ZN=n390 VSS=VSS VDD=VDD I=n97
XU277 INVD0BWP7T $PINS ZN=n388 VSS=VSS VDD=VDD I=n293
XU167 INVD0BWP7T $PINS ZN=n379 VSS=VSS VDD=VDD I=n226
XU134 INVD1BWP7T $PINS ZN=n378 VSS=VSS VDD=VDD I=n61
XU100 INVD1BWP7T $PINS ZN=n377 VSS=VSS VDD=VDD I=n356
XU86 INVD0BWP7T $PINS ZN=n376 VSS=VSS VDD=VDD I=n27
XU71 INVD0BWP7T $PINS ZN=n374 VSS=VSS VDD=VDD I=n348
XU22 INVD0BWP7T $PINS ZN=n367 VSS=VSS VDD=VDD I=n238
XU18 INVD1BWP7T $PINS ZN=n366 VSS=VSS VDD=VDD I=n30
XU373 OAI211D1BWP7T $PINS A2=n362 ZN=sout<6> A1=n363 B=n361 VDD=VDD C=n360
+ VSS=VSS
XU372 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n228 ZN=n360 A3=n357 A2=n358 A1=n396
XU369 AOI22D0BWP7T $PINS B1=n346 A2=n347 ZN=n361 A1=n348 VDD=VDD B2=n345
+ VSS=VSS
XU368 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n343 ZN=n345 A1=n344 A3=n342 A4=n341
XU367 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n246 B1=n358 B2=n339 B3=n338 ZN=n343
XU365 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n333 ZN=n334 A2=n332
XU364 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n330 ZN=n347 A1=n442 A3=n329 A4=n328
XU363 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n327 B1=n326 B2=n418 B3=n324 ZN=n329
XU362 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n330 A1=n323 A3=n321 A2=n322
XU359 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n316 A1=n312 A3=n310 A2=n311
XU356 IND4D0BWP7T $PINS VSS=VSS A1=n302 VDD=VDD B1=n179 B2=n300 B3=n299 ZN=n303
XU355 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n296 A2=n38 A1=n298 ZN=n299 C=n295
XU354 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n293 ZN=n305 A1=n294 A3=n382 A4=n314
XU352 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n287 A1=n288 ZN=n289 A3=n286
XU351 NR4D0BWP7T $PINS VSS=VSS A4=n338 VDD=VDD ZN=n286 A3=n285 A2=n321 A1=n296
XU350 NR4D0BWP7T $PINS VSS=VSS A4=n304 VDD=VDD ZN=n287 A3=n282 A2=n283 A1=n284
XU347 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n276 A1=n275 A3=n291 A2=n274
XU345 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n273 ZN=n310 A2=n272
XU343 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n269 ZN=n270 A1=n294 A3=n268 A4=n267
XU342 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n311 A2=n265 A1=n18 ZN=n268 C=n323
XU341 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<0> ZN=n265 A2=n264
XU339 OAI211D1BWP7T $PINS A2=n377 ZN=sout<4> A1=n259 B=n257 VDD=VDD C=n256
+ VSS=VSS
XU337 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n251 ZN=n253 A1=n252 A3=n250 A4=n385
XU335 AOI22D1BWP7T $PINS B1=n346 A2=n244 ZN=n257 A1=n279 VDD=VDD B2=n243
+ VSS=VSS
XU334 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n246 ZN=n243 A1=n442 A3=n242 A4=n241
XU333 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n261 B1=n321 B2=n355 B3=n319 ZN=n241
XU332 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n240 ZN=n319 A2=n239
XU331 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n236 A2=n90 A1=n238 ZN=n240 C=n235
XU330 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n233 A2=n18 A1=n17 ZN=n242 C=n388
XU329 IND4D0BWP7T $PINS VSS=VSS A1=n302 VDD=VDD B1=n231 B2=n230 B3=n229 ZN=n244
XU328 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n390 ZN=n229 A2=n227
XU325 IND4D0BWP7T $PINS VSS=VSS A1=n219 VDD=VDD B1=n269 B2=n218 B3=n129 ZN=n220
XU323 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n214 ZN=n215 A2=n239
XU322 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n252 A1=n290 ZN=n216
XU321 OAI211D1BWP7T $PINS A2=n212 ZN=n221 A1=n213 B=n211 VDD=VDD C=n327 VSS=VSS
XU320 AOI32D1BWP7T $PINS B2=n430 B1=n377 ZN=sout<3> A1=n210 A2=n430 VDD=VDD
+ A3=n208 VSS=VSS
XU319 NR4D1BWP7T $PINS VSS=VSS A4=n206 VDD=VDD ZN=n208 A3=n420 A2=n290 A1=n335
XU316 NR4D0BWP7T $PINS VSS=VSS A4=n197 VDD=VDD ZN=n201 A3=n198 A2=n199 A1=n275
XU315 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n206 ZN=n251 A2=n338
XU308 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n38 ZN=n182 A2=n54
XU306 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n278 ZN=n205 A1=n231 A3=n175 A4=n234
XU303 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n272 ZN=n171 A2=n177
XU302 NR4D0BWP7T $PINS VSS=VSS A4=n388 VDD=VDD ZN=n175 A3=n236 A2=n169 A1=n274
XU298 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n378 ZN=n167 A2=n260
XU297 OAI211D1BWP7T $PINS A2=n377 ZN=sout<2> A1=n164 B=n163 VDD=VDD C=n162
+ VSS=VSS
XU293 AOI21D0BWP7T $PINS VSS=VSS A2=n154 VDD=VDD A1=n279 B=n153 ZN=n163
XU166 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n326 A2=n29
XU309 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n182 ZN=n349 A1=n273 A3=n181 A4=n380
XU16 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=sin<1> ZN=n104 A2=sin<2>
XU210 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n284 A2=n245 A1=n38 ZN=n59 C=n159
XU224 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n109 B1=n191 B2=n64 B3=n222 ZN=n67
XU219 NR3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n288 A1=n185 A3=n60 A2=n110
XU102 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n85 ZN=n324 A1=n8 A3=n129 A4=n260
XU273 OAI211D1BWP7T $PINS A2=n212 ZN=n233 A1=n439 B=n156 VDD=VDD C=n119 VSS=VSS
XU327 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n226 ZN=n227 A1=n315 A3=n225 A4=n224
XU174 AOI31D2BWP7T $PINS B=n283 ZN=n230 A1=sin<2> A2=n31 VDD=VDD A3=n48 VSS=VSS
XU267 NR4D1BWP7T $PINS VSS=VSS A4=n219 VDD=VDD ZN=n139 A3=n191 A2=n185 A1=n128
XU37 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n118 A1=n247 ZN=n105 A2=n23
XU254 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n252 ZN=n95 A3=n450 A2=n12 A1=n92
XU241 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n81 ZN=n88 A1=n82 A3=n381 A4=n239
XU252 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n340 A1=n128 A3=n89 A2=n168
XU46 OAI211D0BWP7T $PINS A2=n29 ZN=n359 A1=n147 B=n4 VDD=VDD C=n109 VSS=VSS
XU340 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n262 ZN=n271 A1=n263 A3=n261 A4=n260
XU344 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n346 ZN=n309 A3=n270 A2=n359 A1=n271
XU349 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n279 ZN=n308 A3=n280 A2=n281 A1=n310
XU19 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n112 A2=n70
XU156 NR4D0BWP7T $PINS VSS=VSS A4=n282 VDD=VDD ZN=n24 A3=n135 A2=n322 A1=n312
XU62 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n214 B1=n106 B2=n44 B3=n21 ZN=n5
XU68 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n5 ZN=n65 A1=n158 A3=n218 A4=n381
XU89 NR4D1BWP7T $PINS VSS=VSS A4=n83 VDD=VDD ZN=n6 A3=n135 A2=n102 A1=n45
XU92 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n6 ZN=n7 A1=n137 A3=n314 A4=n93
XU361 NR4D1BWP7T $PINS VSS=VSS A4=n317 VDD=VDD ZN=n363 A3=n318 A2=n319 A1=n320
XU272 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n118 ZN=n206 A1=n314 A3=n214 A4=n239
XU228 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n166 A1=n138 ZN=n290 A3=n342
XU281 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n197 A2=n107 A1=n134 ZN=n210
+ C=n132
XU311 AOI31D1BWP7T $PINS B=n362 ZN=n204 A1=n188 A2=n209 VDD=VDD A3=n425 VSS=VSS
XU294 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n156 ZN=n161 A1=n157 A3=n342 A4=n155
XU274 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n122 ZN=n124 A1=n123 A3=n121 A4=n193
XU388 OAI211D2BWP7T $PINS A2=n212 ZN=n405 A1=n439 B=n156 VDD=VDD C=n119 VSS=VSS
XU275 NR4D1BWP7T $PINS VSS=VSS A4=n124 VDD=VDD ZN=n164 A3=n405 A2=n206 A1=n125
XU292 AOI31D0BWP7T $PINS B=n374 ZN=n153 A1=n231 A2=n300 VDD=VDD A3=n152 VSS=VSS
XU235 NR4D1BWP7T $PINS VSS=VSS A4=n73 VDD=VDD ZN=n75 A3=n198 A2=n335 A1=n74
XU338 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n348 ZN=n256 A3=n253 A2=n254 A1=n255
XU270 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n228 ZN=n115 A3=n114 A2=n339 A1=n320
XU238 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n79 A1=n159 A2=n110 A4=n304 A3=n285
XU269 OAI211D1BWP7T $PINS VSS=VSS C=n180 VDD=VDD A2=n367 ZN=n114 A1=n91 B=n139
XU284 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n136 A1=n295 A2=n236 A4=n235 A3=n143
XU268 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n113 A1=n112 A2=n199 A4=n110 A3=n111
XU76 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n312 ZN=n328
XU407 INVD0BWP7T $PINS ZN=n425 VSS=VSS VDD=VDD I=n426
XU358 ND4D4BWP7T $PINS VSS=VSS VDD=VDD A2=n146 ZN=sout<5> A1=n144 A3=n176
+ A4=n133
XU379 OAI211D0BWP7T $PINS A2=n29 ZN=n396 A1=n147 B=n4 VDD=VDD C=n109 VSS=VSS
XU246 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n326 ZN=n385
XU299 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n355 A1=n332 A2=n385 A3=n166
XU168 IND4D1BWP7T $PINS VSS=VSS A1=n172 VDD=VDD B1=n333 B2=n385 ZN=n101 B3=n138
XU221 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n63 A1=n62 A2=n169 A4=n102 A3=n61
XU169 INVD0BWP7T $PINS ZN=n380 VSS=VSS VDD=VDD I=n135
XU110 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n11 ZN=n53 A2=n91
XU69 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n47 ZN=n56 A2=n72
XU75 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n29 ZN=n312 A2=n72
XU326 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n259 A1=n223 A2=n222 A4=n220 A3=n221
XU177 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n187 A1=n295 A2=n101 A4=n32 A3=n33
XU234 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n77 ZN=n73 A1=n288 A3=n177 A4=n224
XU305 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n174 A1=n173 A2=n172 A4=n170 A3=n171
XU300 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n278 A1=n168 A2=n223 A4=n355 A3=n167
XU278 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n130 A1=n128 A2=n168 A4=n126 A3=n127
XU313 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n202 A1=n192 A2=n236 A4=n351 A3=n191
XU202 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n82 A1=n106 A2=n236 A4=n143 A3=n111
XU173 OAI21D2BWP7T $PINS A2=n91 A1=n72 ZN=n283 VDD=VDD B=n156 VSS=VSS
XU259 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n194 A2=n218 ZN=n302 A1=n100 A4=n352
XU314 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n194 A2=n195 ZN=n338 A1=n196 A4=n193
XU253 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n127 ZN=n252
XU198 INR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n294 B1=n128 A1=n272
XU95 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n200 ZN=n346
XU288 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n145 ZN=n223 A2=n91
XU56 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n44 A2=n376
XU194 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n178 ZN=n169
XU122 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n47 ZN=n61 A2=n11
XU82 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n213 ZN=n135 A2=n450
XU66 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n47 ZN=n199 A2=n439
XU32 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=sin<2> ZN=n245 A2=n48
XU40 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n12 ZN=n72 A2=n238
XU15 ND3D2BWP7T $PINS A1=sin<5> VSS=VSS VDD=VDD A3=sin<4> A2=sin<3> ZN=n30
XU402 OAI211D1BWP7T $PINS A2=n449 ZN=n419 A1=n450 B=n178 VDD=VDD C=n100 VSS=VSS
XU401 OAI211D2BWP7T $PINS A2=n145 ZN=n418 A1=n47 B=n157 VDD=VDD C=n315 VSS=VSS
XU400 OAI211D0BWP7T $PINS A2=n29 ZN=n417 A1=n147 B=n4 VDD=VDD C=n109 VSS=VSS
XU131 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n192 ZN=n157
XU175 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n44 ZN=n293 A1=n118
XU370 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n350 A2=n351 A1=sin<1> ZN=n354
+ C=n349
XU366 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n337 B1=n336 B2=n335 B3=n334 ZN=n344
XU179 NR4D0BWP7T $PINS VSS=VSS A4=n322 VDD=VDD ZN=n34 A3=n111 A2=n56 A1=n192
XU317 AOI31D1BWP7T $PINS B=n200 ZN=n203 A1=n186 A2=n251 VDD=VDD A3=n201 VSS=VSS
XU256 NR4D0BWP7T $PINS VSS=VSS A4=n94 VDD=VDD ZN=n96 A3=n95 A2=n290 A1=n295
XU249 NR4D0BWP7T $PINS VSS=VSS A4=n281 VDD=VDD ZN=n87 A3=n86 A2=n336 A1=n169
XU295 IIND4D0BWP7T $PINS VSS=VSS A1=n159 VDD=VDD ZN=n160 B1=n158 B2=n179
+ A2=n350
XU346 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n314 A1=n382 ZN=n291 A3=n337
XU392 AN3D2BWP7T $PINS VSS=VSS A1=n451 VDD=VDD A2=sin<3> A3=sin<5> Z=n31
XU391 INVD0BWP7T $PINS ZN=n451 VSS=VSS VDD=VDD I=sin<4>
XU390 OR3D2BWP7T $PINS VSS=VSS A3=sin<2> VDD=VDD A2=sin<1> A1=sin<0> Z=n450
XU387 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n449 A2=n145 A1=sin<5>
XU385 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n295 A2=n232 A1=n366
XU383 OAI211D1BWP7T $PINS VSS=VSS C=n315 VDD=VDD A2=n145 ZN=n406 A1=n47 B=n157
XU382 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n49 A3=n406 A2=n169 A1=n447 Z=n446
XU381 INVD0BWP7T $PINS ZN=n447 VSS=VSS VDD=VDD I=n273
XU380 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n122 I=n446
XU378 AO211D0BWP7T $PINS Z=n445 C=n323 B=n326 A2=n13 VDD=VDD A1=n107 VSS=VSS
XU377 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n142 A3=n172 A2=n322 A1=n56 Z=n444
XU376 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n137 I=n444
XU357 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n14 A3=n350 A2=n321 A1=n61 Z=n443
XU324 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n300 I=n443
XU310 AN4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n226 A3=n194 A4=n337 Z=n442 A1=n63
XU287 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n442 ZN=n222
XU243 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n131 I=n445
XU233 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n140 A3=n141 A2=n142 A1=n143 Z=n441
XU223 INVD0BWP7T $PINS ZN=n231 VSS=VSS VDD=VDD I=n441
XU206 IINR4D1BWP7T $PINS VSS=VSS A1=n250 VDD=VDD ZN=n4 B1=n105 B2=n3 A2=n42
XU200 OA31D0BWP7T $PINS Z=n440 B=n267 A3=n72 A2=sin<2> A1=sin<0> VDD=VDD
+ VSS=VSS
XU196 INVD0BWP7T $PINS ZN=n198 VSS=VSS VDD=VDD I=n440
XU191 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n228 ZN=n397 A3=n304 A2=n305 A1=n303
XU183 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n211 A2=n131 ZN=n394 A1=n55 A4=n438
XU165 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n439 A2=n147 A1=sin<3>
XU138 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n438 A2=n376 A1=n364
XU96 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n322 A2=n38 A1=n232
XU78 AO21D0BWP7T $PINS Z=n142 B=n312 A1=n54 VDD=VDD A2=n38 VSS=VSS
XU72 OA31D0BWP7T $PINS Z=n437 B=n348 A3=n15 A2=n254 A1=n324 VDD=VDD VSS=VSS
XU64 OA31D0BWP7T $PINS Z=n436 B=n279 A3=n25 A2=n26 A1=n112 VDD=VDD VSS=VSS
XU48 OR4D4BWP7T $PINS VSS=VSS A4=n165 VDD=VDD A3=n437 A2=n435 A1=n436 Z=sout<7>
XU42 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n349 A3=n183 A2=n184 A1=n185 Z=n426
XU38 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n269 A1=n216 A2=n215 A4=n321 A3=n304
XU35 OA31D0BWP7T $PINS Z=n435 B=n346 A3=n65 A2=n7 A1=n417 VDD=VDD VSS=VSS
XU199 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n85 ZN=n49 A1=n294 A3=n109 A4=n100
XU132 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n262 ZN=n14 A1=n195 A3=n71 A4=n157
XU403 OAI211D1BWP7T $PINS VSS=VSS C=n100 VDD=VDD A2=n449 ZN=n420 A1=n450 B=n178
XU237 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n378 A2=n195 ZN=n125 A1=n77 A4=n260
XU136 IND3D1BWP7T $PINS ZN=n15 B2=n196 B1=n300 VDD=VDD A1=n126 VSS=VSS
XU50 OAI21D1BWP7T $PINS A2=n35 A1=n38 ZN=n158 VDD=VDD B=n107 VSS=VSS
XU121 OAI211D2BWP7T $PINS ZN=n126 A2=n30 A1=n104 C=n181 VDD=VDD B=n273 VSS=VSS
XU109 OAI211D1BWP7T $PINS VSS=VSS C=n100 VDD=VDD A2=n449 ZN=n207 A1=n450 B=n178
XU353 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n204 A2=n190 A1=n348 ZN=n430 C=n203
XU318 OAI31D1BWP7T $PINS B=n348 A3=n289 ZN=n429 A2=n290 VDD=VDD A1=n291 VSS=VSS
XU147 NR4D1BWP7T $PINS VSS=VSS A4=n141 VDD=VDD ZN=n121 A3=n127 A2=n168 A1=n185
XU21 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n23 A1=sin<5> A2=sin<4> A3=n12
XU34 NR2D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n16 A1=n48 A2=n2
XU33 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n245 ZN=n247 A2=n19
XU6 INVD0BWP7T $PINS ZN=n19 VSS=VSS VDD=VDD I=sin<1>
XU45 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n16 ZN=n109 A2=n35
XU187 NR3D1BWP7T $PINS A3=n41 VSS=VSS VDD=VDD A1=n62 A2=n53 ZN=n188
XU296 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n346 ZN=n162 A3=n160 A2=n320 A1=n161
XU204 INR4D2BWP7T $PINS ZN=n55 A1=n77 B3=n52 B2=n173 VDD=VDD B1=n53 VSS=VSS
Xicc_clock3 DEL1BWP7T $PINS VSS=VSS VDD=VDD I=n76 Z=n37
Xicc_clock4 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n151 I=n202
Xicc_clock5 AOI211XD1BWP7T $PINS ZN=n179 A2=n35 A1=n298 C=n168 VDD=VDD B=n83
+ VSS=VSS
Xicc_clock6 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n228 I=n356
Xicc_clock7 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n232 I=n80
Xicc_place3 CKND2BWP7T $PINS VSS=VSS I=sin<3> VDD=VDD ZN=n12
Xicc_place5 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n17 I=n104
Xicc_place11 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n40 I=sin<7>
Xicc_place14 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n70 I=n46
Xicc_place19 INVD0BWP7T $PINS ZN=n120 VSS=VSS VDD=VDD I=n311
Xicc_place21 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n397 Z=n133
Xicc_place22 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n309 Z=n144
Xicc_place23 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n308 Z=n146
Xicc_place24 OA31D0BWP7T $PINS Z=n165 B=n356 A3=n36 A2=n173 A1=n61 VDD=VDD
+ VSS=VSS
Xicc_place25 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n176 I=n429
Xicc_place27 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n180 I=n113
Xicc_place28 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n186 I=n151
Xicc_place20 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n45 ZN=n129
Xicc_place18 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n247 ZN=n107
Xicc_place9 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=n38 I=n449
Xicc_place17 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n80 ZN=n91
Xicc_place15 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n29 ZN=n84
Xicc_place13 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n450 ZN=n54
Xicc_place10 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n439 ZN=n39
Xicc_place6 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n11 ZN=n18
Xicc_place4 INVD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n23 ZN=n13
Xicc_place7 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n213 ZN=n28
Xicc_place8 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n72 ZN=n35
Xicc_place16 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n47 ZN=n90
Xicc_place12 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n48 I=sin<0>
Xicc_place26 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n189 I=n98
Xicc_place29 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n190 I=n205
Xicc_place30 DEL1BWP7T $PINS VSS=VSS VDD=VDD I=n187 Z=n209
Xicc_place31 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n217 I=n237
.ENDS

.SUBCKT clefia_round rout<127> rout<126> rout<125> rout<124> rout<123>
+ rout<122> rout<121> rout<120> rout<119> rout<118> rout<117> rout<116>
+ rout<115> rout<114> rout<113> rout<112> rout<111> rout<110> rout<109>
+ rout<108> rout<107> rout<106> rout<105> rout<104> rout<103> rout<102>
+ rout<101> rout<100> rout<99> rout<98> rout<97> rout<96> rout<95> rout<94>
+ rout<93> rout<92> rout<91> rout<90> rout<89> rout<88> rout<87> rout<86>
+ rout<85> rout<84> rout<83> rout<82> rout<81> rout<80> rout<79> rout<78>
+ rout<77> rout<76> rout<75> rout<74> rout<73> rout<72> rout<71> rout<70>
+ rout<69> rout<68> rout<67> rout<66> rout<65> rout<64> rout<63> rout<62>
+ rout<61> rout<60> rout<59> rout<58> rout<57> rout<56> rout<55> rout<54>
+ rout<53> rout<52> rout<51> rout<50> rout<49> rout<48> rout<47> rout<46>
+ rout<45> rout<44> rout<43> rout<42> rout<41> rout<40> rout<39> rout<38>
+ rout<37> rout<36> rout<35> rout<34> rout<33> rout<32> rout<31> rout<30>
+ rout<29> rout<28> rout<27> rout<26> rout<25> rout<24> rout<23> rout<22>
+ rout<21> rout<20> rout<19> rout<18> rout<17> rout<16> rout<15> rout<14>
+ rout<13> rout<12> rout<11> rout<10> rout<9> rout<8> rout<7> rout<6> rout<5>
+ rout<4> rout<3> rout<2> rout<1> rout<0> rin<127> rin<126> rin<125> rin<124>
+ rin<123> rin<122> rin<121> rin<120> rin<119> rin<118> rin<117> rin<116>
+ rin<115> rin<114> rin<113> rin<112> rin<111> rin<110> rin<109> rin<108>
+ rin<107> rin<106> rin<105> rin<104> rin<103> rin<102> rin<101> rin<100>
+ rin<99> rin<98> rin<97> rin<96> rin<95> rin<94> rin<93> rin<92> rin<91>
+ rin<90> rin<89> rin<88> rin<87> rin<86> rin<85> rin<84> rin<83> rin<82>
+ rin<81> rin<80> rin<79> rin<78> rin<77> rin<76> rin<75> rin<74> rin<73>
+ rin<72> rin<71> rin<70> rin<69> rin<68> rin<67> rin<66> rin<65> rin<64>
+ rin<63> rin<62> rin<61> rin<60> rin<59> rin<58> rin<57> rin<56> rin<55>
+ rin<54> rin<53> rin<52> rin<51> rin<50> rin<49> rin<48> rin<47> rin<46>
+ rin<45> rin<44> rin<43> rin<42> rin<41> rin<40> rin<39> rin<38> rin<37>
+ rin<36> rin<35> rin<34> rin<33> rin<32> rin<31> rin<30> rin<29> rin<28>
+ rin<27> rin<26> rin<25> rin<24> rin<23> rin<22> rin<21> rin<20> rin<19>
+ rin<18> rin<17> rin<16> rin<15> rin<14> rin<13> rin<12> rin<11> rin<10>
+ rin<9> rin<8> rin<7> rin<6> rin<5> rin<4> rin<3> rin<2> rin<1> rin<0> rk0<31>
+ rk0<30> rk0<29> rk0<28> rk0<27> rk0<26> rk0<25> rk0<24> rk0<23> rk0<22>
+ rk0<21> rk0<20> rk0<19> rk0<18> rk0<17> rk0<16> rk0<15> rk0<14> rk0<13>
+ rk0<12> rk0<11> rk0<10> rk0<9> rk0<8> rk0<7> rk0<6> rk0<5> rk0<4> rk0<3>
+ rk0<2> rk0<1> rk0<0> rk1<31> rk1<30> rk1<29> rk1<28> rk1<27> rk1<26> rk1<25>
+ rk1<24> rk1<23> rk1<22> rk1<21> rk1<20> rk1<19> rk1<18> rk1<17> rk1<16>
+ rk1<15> rk1<14> rk1<13> rk1<12> rk1<11> rk1<10> rk1<9> rk1<8> rk1<7> rk1<6>
+ rk1<5> rk1<4> rk1<3> rk1<2> rk1<1> rk1<0> VDD VSS
Xx_sbox12 clefia_sbox1_0 $PINS sout<7>=sout1<15> sout<6>=sout1<14>
+ sout<5>=sout1<13> sout<4>=sout1<12> sout<3>=sout1<11> sout<2>=sout1<10>
+ sout<1>=sout1<9> sout<0>=sout1<8> sin<7>=sin1<15> sin<6>=sin1<14>
+ sin<5>=sin1<13> sin<4>=n2134 sin<3>=sin1<11> sin<2>=sin1<10> sin<1>=sin1<9>
+ sin<0>=sin1<8> VDD=VDD VSS=VSS
Xx_sbox10 clefia_sbox1_1 $PINS sout<7>=n1480 sout<6>=sout1<30>
+ sout<5>=sout1<29> sout<4>=sout1<28> sout<3>=sout1<27> sout<2>=sout1<26>
+ sout<1>=sout1<25> sout<0>=sout1<24> sin<7>=sin1<31> sin<6>=sin1<30>
+ sin<5>=sin1<29> sin<4>=sin1<28> sin<3>=sin1<27> sin<2>=sin1<26> sin<1>=sin1<25>
+ sin<0>=sin1<24> VSS=VSS VDD=VDD
Xx_sbox03 clefia_sbox1_2 $PINS sout<7>=sout0<7> sout<6>=sout0<6>
+ sout<5>=sout0<5> sout<4>=sout0<4> sout<3>=sout0<3> sout<2>=sout0<2>
+ sout<1>=sout0<1> sout<0>=sout0<0> sin<7>=sin0<7> sin<6>=sin0<6> sin<5>=sin0<5>
+ sin<4>=sin0<4> sin<3>=sin0<3> sin<2>=sin0<2> sin<1>=sin0<1> sin<0>=sin0<0>
+ VDD=VDD VSS=VSS
Xicc_route_opt8 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n193 I=n201
Xicc_route_opt7 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n182 I=n632
Xicc_route_opt6 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n177 I=n456
Xicc_route_opt5 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n171 I=n9
Xicc_route_opt4 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1695 Z=n163
Xicc_route_opt3 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n160 I=n1801
Xicc_route_opt2 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1900 Z=n149
Xicc_route_opt1 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n148 I=n283
XU1406 INVD1BWP7T $PINS ZN=n1474 VSS=VSS VDD=VDD I=n1457
XU1403 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1438 ZN=n1475 A2=n1216
XU1458 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1274 ZN=n1846 A1=n1067 A3=n1066
+ A4=n1237
XU1457 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n1797 ZN=n1274 A2=n1351
XU1407 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n1279 ZN=n1067 A2=n1474
XU1617 NR4D1BWP7T $PINS VSS=VSS A4=n1518 VDD=VDD ZN=n1097 A3=n1597 A2=n1209
+ A1=n1041
XU1614 INVD1BWP7T $PINS ZN=n1209 VSS=VSS VDD=VDD I=n1643
XU1616 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1698 ZN=n1518 A2=n1523
XU287 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n306 A2=n186 A1=n793 ZN=n423
+ C=n865
XU1419 INR2D2BWP7T $PINS VSS=VSS VDD=VDD B1=n1364 ZN=n1803 A1=n1266
Xicc_place180 OAI22D1BWP7T $PINS ZN=n1883 A1=n376 A2=n1005 B2=n980 VDD=VDD
+ B1=n375 VSS=VSS
XU464 INVD1BWP7T $PINS ZN=n2256 VSS=VSS VDD=VDD I=n1537
XU1828 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1842 ZN=n1811 A2=n1258
XU1827 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1456 ZN=n1258 A1=n936 A3=n1257
+ A4=n1415
XU900 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2044 ZN=n579 A2=n355
XU1074 AO211D0BWP7T $PINS Z=n829 C=n579 B=n2019 A2=n682 VDD=VDD A1=n511 VSS=VSS
XU577 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n336 B1=n2019 B2=n529 B3=n506
+ ZN=n159
XU806 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n615 ZN=n1966 A2=n911
XU690 INVD1BWP7T $PINS ZN=n454 VSS=VSS VDD=VDD I=n798
XU1742 NR3D1BWP7T $PINS A3=n1178 VSS=VSS VDD=VDD A1=n1674 A2=n1179 ZN=n1329
XU1741 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2288 ZN=n1178 A1=n1177 A3=n2255
+ A4=n2271
XU903 IND4D0BWP7T $PINS VSS=VSS A1=n831 VDD=VDD B1=n360 B2=n2006 B3=n359
+ ZN=n1001
XU257 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n1928 ZN=n43 A3=n26 A2=n866 A1=n213
XU931 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n387 ZN=n771 A2=n386
XU667 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2217 ZN=n386 A2=n925
XU435 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n104 A1=n362 A2=n846 A4=n165 A3=n1004
XU115 NR2D8BWP7T $PINS VSS=VSS VDD=VDD A1=n2 A2=n890 ZN=n873
XU114 CKND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n516 ZN=n890 A2=n5
XU2367 CKXOR2D4BWP7T $PINS A1=rin<109> VDD=VDD VSS=VSS A2=n651 Z=n2
XU2207 AOI31D1BWP7T $PINS B=n1968 ZN=n1983 A1=n1971 A2=n1316 VDD=VDD A3=n1969
+ VSS=VSS
XU1119 OA31D2BWP7T $PINS Z=n1971 B=n2765 A3=n795 A2=n620 A1=n745 VDD=VDD
+ VSS=VSS
XU465 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n566 ZN=n352 A2=n817
Xicc_place54 INVD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n817 I=n334
XU1044 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n2036 ZN=n534 A3=n532 A2=n533
+ A1=n979
XU226 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n213 A1=n32 A2=n70 A3=n280
XU163 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2161 ZN=n1907 A2=n33
XU2015 NR4D1BWP7T $PINS VSS=VSS A4=n1582 VDD=VDD ZN=n1586 A3=n1583 A2=n1584
+ A1=n2224
XU243 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n286 ZN=n416 A2=n648
XU1031 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n550 A1=n2067 A2=n546 A4=n510
+ A3=n2016
XU859 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n299 ZN=n301 A1=n300 A3=n298 A4=n297
XU922 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n796 ZN=n741 A2=n381
XU1210 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n875 ZN=n1925 A2=n1995
XU767 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1102 ZN=n464 A2=n2244
XU687 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1101 ZN=n928 A2=n2245
XU206 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n321 ZN=n17 A1=n59 A3=n1089 A4=n420
XU1086 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n804 ZN=n635 A1=n733 A3=n599 A4=n598
XU622 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1143 A1=n203 ZN=n208 A3=n894
XU1121 IND4D1BWP7T $PINS VSS=VSS A1=n669 VDD=VDD B1=n668 B2=n667 B3=n673
+ ZN=n670
XU318 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n903 A1=n1244 A2=n1889 A4=n63 A3=n308
XU562 NR4D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n538 A1=n507 A2=n352 A4=n147 A3=n162
XU697 INVD1BWP7T $PINS ZN=n1960 VSS=VSS VDD=VDD I=n776
XU979 OAI31D1BWP7T $PINS B=n892 A3=n431 ZN=n449 A2=n432 VDD=VDD A1=n433 VSS=VSS
XU1172 NR4D1BWP7T $PINS VSS=VSS A4=n786 VDD=VDD ZN=n779 A3=n1944 A2=n777
+ A1=n778
XU856 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n429 ZN=n291 A1=n290 A3=n1143 A4=n299
XU770 INVD2BWP7T $PINS ZN=n943 VSS=VSS VDD=VDD I=n695
XU258 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n317 ZN=n437 A2=n27
XU255 INVD0BWP7T $PINS ZN=n40 VSS=VSS VDD=VDD I=n25
XU254 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n24 ZN=n26 A1=n660 A3=n314 A4=n673
XU253 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n314 A2=n38
XU251 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n877 ZN=n22 A1=n657 A3=n2315 A4=n187
XU250 INVD0BWP7T $PINS ZN=n187 VSS=VSS VDD=VDD I=n50
XU248 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n20 A1=n21 ZN=n27
XU246 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n854 ZN=n277 A2=n196
XU245 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n19 ZN=n196 A2=n681
XU240 INVD0BWP7T $PINS ZN=n184 VSS=VSS VDD=VDD I=n299
XU239 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1891 ZN=n660 A2=n637
XU238 INVD0BWP7T $PINS ZN=n637 VSS=VSS VDD=VDD I=n212
XU236 INVD0BWP7T $PINS ZN=n81 VSS=VSS VDD=VDD I=n894
XU235 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n19 ZN=n894 A2=n793
XU232 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n35 ZN=n209 A2=n18
XU231 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n873 ZN=n195 A2=n276
XU225 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n873 ZN=n280 A2=n793
XU224 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n70 A2=n876 A1=n320
XU223 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n896 ZN=n320 A2=n1095
XU221 CKND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n1916 A2=n25
XU219 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n678 ZN=n16 A1=n79 A3=n32 A4=n56
XU216 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2235 ZN=n298 A2=n1108
XU215 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n853 A2=n896
XU214 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n35 ZN=n876 A2=n38
XU213 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n873 ZN=n854 A2=n18
XU212 INVD0BWP7T $PINS ZN=n311 VSS=VSS VDD=VDD I=n60
XU211 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n214 ZN=n60 A2=n858
XU210 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n87 ZN=n32 A2=n279
XU208 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n643 ZN=n87 A2=n417
XU205 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n681 ZN=n420 A2=n23
XU200 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n286 ZN=n59 A2=n50
XU197 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2302 ZN=n430 A2=n897
XU192 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n672 A2=n276
XU189 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n203 A2=n673 A1=n855
XU188 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n19 ZN=n673 A2=n276
XU187 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n681 ZN=n855 A2=n71
XU184 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n650 ZN=n1901 A2=n19
XU183 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n29 ZN=n19
XU181 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n324 ZN=n13 A2=n299
XU180 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n35 ZN=n299 A2=n793
XU179 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n304 ZN=n324 A2=n882
XU177 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n417 ZN=n304 A2=n1182
XU176 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n905 ZN=n192 A2=n668
XU173 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2235 ZN=n897 A2=n23
XU171 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n200 ZN=n1904 A2=n1892
XU170 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n80 ZN=n1892 A2=n1182
XU162 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n85 ZN=n21 A2=n1924
XU161 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n276 ZN=n1924 A2=n71
XU158 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1108 ZN=n85 A2=n896
XU154 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n877 ZN=n287
XU153 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n877 A2=n18
XU147 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n23 ZN=n300 A2=n793
XU132 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3 ZN=n7 A2=n2209
XU130 INVD1BWP7T $PINS ZN=n10 VSS=VSS VDD=VDD I=n667
XU129 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n185 ZN=n667 A2=n23
XU102 XOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<105> A2=rk0<9> Z=n5
XU99 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n6 ZN=n644 A2=n3
XU98 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n72 ZN=n6
XU96 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n72 ZN=n53 A2=n3
XU92 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<106> A2=rk0<10> Z=n418
XU90 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<111> A2=rk0<15> ZN=n25
XU88 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<8> A2=rin<40> Z=sin1<8>
XU81 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<15> A2=rin<47> Z=sin1<15>
XU73 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n2579 A2=rin<63> Z=sin1<31>
XU69 CKXOR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n2585 A2=rin<99> Z=sin0<3>
XU65 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n2563 A2=rin<103> Z=sin0<7>
XU39 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=rin<102> Z=rout<6>
XU474 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n370 ZN=n359 A2=n334
XU473 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n535 ZN=n129 A2=n578
XU472 INVD0BWP7T $PINS ZN=n578 VSS=VSS VDD=VDD I=n497
XU471 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n859 ZN=n497 A2=n731
XU470 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n353 ZN=n535
XU469 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n682 ZN=n353 A2=n787
XU461 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n756 ZN=n985 A2=n335
XU459 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n520 A1=n995 ZN=n121
XU458 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n814 ZN=n520 A2=n787
XU456 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n558 ZN=n162
XU455 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n558 A2=n859
XU452 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n1004 A3=n552 A2=n536 A1=n106 Z=n114
XU451 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n973 ZN=n552 A2=n991
XU450 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n685 ZN=n991 A2=n125
XU449 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n153 ZN=n536 A2=n355
XU448 INVD0BWP7T $PINS ZN=n106 VSS=VSS VDD=VDD I=n2006
XU447 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n814 ZN=n2006 A2=n859
XU439 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2133 ZN=n105 A1=n1008 A3=n2276
+ A4=n174
XU438 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n814 ZN=n174 A2=n664
XU433 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n685 ZN=n336 A2=n756
XU430 NR4D1BWP7T $PINS VSS=VSS A4=n2021 VDD=VDD ZN=n101 A3=n514 A2=n575 A1=n1
XU429 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n519 ZN=n2021 A2=n144
XU428 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n128 ZN=n144 A2=n119
XU427 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2247 ZN=n519 A2=n334
XU426 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n154 ZN=n514 A2=n131
XU425 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n688 ZN=n131 A2=n125
XU424 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n128 ZN=n154 A2=n334
XU423 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n869 ZN=n575 A2=n2043
XU422 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n99 ZN=n2043 A2=n512
XU419 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n102 A1=n840 A3=n98 A2=n2014
XU417 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n787 ZN=n150 A2=n731
XU413 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n96 ZN=n103 A2=n570
XU409 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n996 ZN=n505 A2=n128
XU402 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n555 ZN=n96 A2=n511
XU399 INVD0BWP7T $PINS ZN=n846 VSS=VSS VDD=VDD I=n973
XU398 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n814 ZN=n973 A2=n335
XU391 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1008 A2=n2009 A1=n524
XU390 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n688 ZN=n2009 A2=n334
XU383 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n145 A1=n361 ZN=n500
XU382 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n152 ZN=n145 A2=n557
XU380 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n372 A2=n664
XU378 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n370 ZN=n156 A2=n511
XU372 INVD0BWP7T $PINS ZN=n152 VSS=VSS VDD=VDD I=n2005
XU371 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n685 ZN=n2005 A2=n334
XU361 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n99 ZN=n97 A2=n176
XU356 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n533 ZN=n570
XU348 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1926 ZN=n88 A1=n656 A3=n877 A4=n895
XU347 INVD0BWP7T $PINS ZN=n895 VSS=VSS VDD=VDD I=n87
XU346 NR4D1BWP7T $PINS VSS=VSS A4=n86 VDD=VDD ZN=n1926 A3=n435 A2=n1896 A1=n866
XU345 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n85 ZN=n86 A2=n1148
XU344 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n298 A1=n674 ZN=n435
XU343 CKND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2330 ZN=n1896 A2=n881
XU342 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n681 A1=n2161 ZN=n881
XU339 INVD0BWP7T $PINS ZN=n319 VSS=VSS VDD=VDD I=n314
XU336 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n675 ZN=n83 A2=n882
XU331 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2315 A1=n74 ZN=n884 A3=n297
XU330 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1915 A2=n426 A1=n185 ZN=n74 C=n287
XU325 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n290 ZN=n68 A2=n2281
XU324 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n1906 ZN=n290 A1=n867
XU319 AOI31D1BWP7T $PINS B=n204 ZN=n66 A1=n72 A2=n1095 VDD=VDD A3=n2209 VSS=VSS
XU314 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n279 ZN=n1908 A2=n1890
XU313 INVD0BWP7T $PINS ZN=n1890 VSS=VSS VDD=VDD I=n663
XU312 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n196 ZN=n308 A2=n867
XU310 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n653 ZN=n665 A2=n327
XU309 INVD1BWP7T $PINS ZN=n653 VSS=VSS VDD=VDD I=n280
XU306 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n57 ZN=n285 A2=n567
XU305 NR4D1BWP7T $PINS VSS=VSS A4=n1053 VDD=VDD ZN=n58 A3=n640 A2=n87 A1=n1915
XU298 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n681 ZN=n654 A2=n1095
XU297 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n876 ZN=n312 A2=n1082
XU295 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n80 ZN=n204 A2=n111
XU293 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n863 ZN=n433 A2=n1909
XU288 NR4D1BWP7T $PINS VSS=VSS A4=n1927 VDD=VDD ZN=n49 A3=n899 A2=n858 A1=n313
XU286 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n321 ZN=n865 A2=n47
XU281 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n645 ZN=n42 A3=n41 A2=n669 A1=n885
XU280 INVD1BWP7T $PINS ZN=n645 VSS=VSS VDD=VDD I=n1933
XU279 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n40 ZN=n1933 A2=n39
XU278 IND4D0BWP7T $PINS VSS=VSS A1=n292 VDD=VDD B1=n443 B2=n1098 B3=n215 ZN=n41
XU277 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1108 ZN=n215 A2=n38
XU274 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n51 ZN=n37 A1=n2281 A3=n663 A4=n867
XU273 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2235 ZN=n867 A2=n71
XU272 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n35 ZN=n663 A2=n896
XU270 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n320 ZN=n302 A2=n673
XU269 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n327 A2=n57
XU268 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1103 ZN=n292 A2=n420
XU266 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n318 ZN=n669 A2=n209
XU265 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1891 ZN=n318 A2=n898
XU262 NR4D0BWP7T $PINS VSS=VSS A4=n900 VDD=VDD ZN=n31 A3=n1927 A2=n899 A1=n675
XU664 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n455 ZN=n479 A2=n390
XU657 INVD1BWP7T $PINS ZN=n614 VSS=VSS VDD=VDD I=n227
XU656 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n961 ZN=n227 A2=n1955
XU654 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2217 ZN=n773 A2=n736
XU653 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2561 ZN=n736 A2=n2196
XU643 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n486 ZN=n224 A2=n921
XU641 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<124> A2=rk0<28> ZN=n620
XU640 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n621 ZN=n486
XU638 XNR4D0BWP7T $PINS A1=n1603 A2=n1494 ZN=n274 A3=rin<92> A4=n414 VDD=VDD
+ VSS=VSS
XU631 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n217 ZN=n218 A1=n678 A3=n216 A4=n215
XU629 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n900 A2=n1108 A1=n872 ZN=n217
+ C=n898
XU626 INVD1BWP7T $PINS ZN=n652 VSS=VSS VDD=VDD I=n209
XU625 NR4D0BWP7T $PINS VSS=VSS A4=n207 VDD=VDD ZN=n220 A3=n208 A2=n425 A1=n899
XU624 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n888 ZN=n207 A1=n206 A3=n1909 A4=n205
XU623 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n204 ZN=n888 A2=n210
XU620 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n202 ZN=n425 A2=n314
XU614 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n878 ZN=n199 A1=n901 A3=n877 A4=n420
XU613 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n276 ZN=n878 A2=n1095
XU612 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n205 A1=n303 A3=n197 A2=n326
XU611 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n196 A1=n1103 ZN=n197 A3=n195
XU607 INVD0BWP7T $PINS ZN=n315 VSS=VSS VDD=VDD I=n191
XU606 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n149 ZN=n1903 A2=n190
XU603 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n184 A2=n185 A1=n186 ZN=n188
+ C=n648
XU598 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n565 ZN=n179 A1=n2003 A3=n178
+ A4=n2276
XU595 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n542 ZN=n366 A2=n990
XU594 INVD0BWP7T $PINS ZN=n363 VSS=VSS VDD=VDD I=n174
XU593 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n173 ZN=n994 A2=n353
XU592 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n2019 A2=n2200 A1=n172 ZN=n173
+ C=n170
XU589 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n166 A1=n506 A3=n164 A2=n165
XU588 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n842 A1=n2013 ZN=n164 A3=n990
XU586 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n162 ZN=n842 A2=n161
XU585 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n354 ZN=n2013 A2=n507
XU584 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n167 A1=n496 A3=n535 A2=n563
XU583 INVD0BWP7T $PINS ZN=n563 VSS=VSS VDD=VDD I=n975
XU578 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n975 ZN=n157 A1=n520 A3=n174 A4=n827
XU573 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2034 ZN=n155 A1=n583 A3=n2278
+ A4=n2033
XU572 INVD0BWP7T $PINS ZN=n2034 VSS=VSS VDD=VDD I=n170
XU571 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n357 ZN=n170 A2=n782
XU570 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2007 ZN=n583 A2=n840
XU568 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n979 ZN=n356 A2=n555
XU566 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n368 A1=n152 A3=n151 A2=n501
XU565 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1009 ZN=n151 A1=n538 A3=n150 A4=n819
XU564 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n172 ZN=n819 A2=n2218
XU563 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n756 ZN=n1009 A2=n664
XU561 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2006 ZN=n147 A2=n553
XU559 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n565 ZN=n146 A1=n351 A3=n543 A4=n991
XU558 AN3D1BWP7T $PINS VSS=VSS A1=n145 VDD=VDD A2=n144 A3=n827 Z=n565
XU554 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n154 A1=n840 ZN=n1003
XU553 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n975 ZN=n993 A2=n497
XU550 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n996 ZN=n974 A2=n335
XU548 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n979 ZN=n571 A2=n2804
XU546 INVD1BWP7T $PINS ZN=n338 VSS=VSS VDD=VDD I=n150
XU542 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1015 ZN=n2045
XU541 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n580 ZN=n1015 A2=n133
XU540 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n132 A1=n1017 ZN=n135 A3=n989
XU539 NR4D0BWP7T $PINS VSS=VSS A4=n175 VDD=VDD ZN=n132 A3=n2018 A2=n501 A1=n992
XU538 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2005 ZN=n2018 A2=n131
XU532 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n128 ZN=n2011 A2=n682
XU530 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n685 ZN=n2008 A2=n731
XU529 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n358 A2=n370 A1=n125 ZN=n127
+ C=n2067
XU527 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n553 ZN=n358 A2=n508
XU526 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2014 ZN=n521 A2=n536
XU525 AO211D1BWP7T $PINS Z=n518 C=n552 B=n161 A2=n124 VDD=VDD A1=n172 VSS=VSS
XU524 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n176 ZN=n172 A2=n342
XU522 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n980 ZN=n2055
XU521 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n122 ZN=n980 A2=n133
XU520 IND4D1BWP7T $PINS VSS=VSS A1=n175 VDD=VDD B1=n837 B2=n143 B3=n2024
+ ZN=n123
XU518 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n542 A1=n345 ZN=n120 A3=n2278
XU516 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n125 ZN=n542 A2=n787
XU514 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n827 A2=n787
XU512 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n566 ZN=n354 A2=n355
XU511 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n361 ZN=n837 A2=n117
XU510 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n508 ZN=n117 A1=n821 A3=n989 A4=n2033
XU509 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n141 ZN=n2033 A2=n685
XU508 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n996 ZN=n989 A2=n2247
XU507 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n128 ZN=n508 A2=n731
XU506 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2007 ZN=n821 A2=n2014
XU505 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n2804 ZN=n2007 A2=n2044
XU503 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n524 ZN=n175 A2=n828
XU499 AN3D1BWP7T $PINS VSS=VSS A1=n553 VDD=VDD A2=n346 A3=n115 Z=n116
XU498 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n685 ZN=n553 A2=n119
XU496 INVD0BWP7T $PINS ZN=n544 VSS=VSS VDD=VDD I=n2051
XU495 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n580 ZN=n2051 A2=n2206
XU492 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n664 ZN=n828 A2=n731
XU487 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n787 ZN=n346 A2=n334
XU483 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n128 ZN=n975 A2=n814
XU482 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n833 ZN=n2017 A2=n115
XU480 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n543 ZN=n108 A1=n129 A3=n984 A4=n150
XU479 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n682 ZN=n984 A2=n664
XU478 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n543 A2=n924 A1=n359
XU820 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n613 ZN=n255 A1=n716 A3=n254 A4=n259
XU819 NR4D0BWP7T $PINS VSS=VSS A4=n2739 VDD=VDD ZN=n254 A3=n468 A2=n724 A1=n778
XU816 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n935 ZN=n723 A2=n387
XU815 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n719 ZN=n249 A2=n1099
XU813 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n722 A2=n705
XU811 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n739 ZN=n785 A2=n1208
XU808 IND4D1BWP7T $PINS VSS=VSS A1=n1966 VDD=VDD B1=n701 B2=n1230 B3=n798
+ ZN=n246
XU807 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n746 ZN=n701 A2=n705
XU805 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n245 ZN=n1973 A2=n2769
XU804 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n762 ZN=n956 A2=n630
XU803 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n243 A3=n244 A2=n718 A1=n478 Z=n630
XU802 IND4D0BWP7T $PINS VSS=VSS A1=n928 VDD=VDD B1=n702 B2=n2308 B3=n738
+ ZN=n243
XU801 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1119 ZN=n702 A2=n263
XU800 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n403 ZN=n762 A2=n721
XU799 INVD0BWP7T $PINS ZN=n721 VSS=VSS VDD=VDD I=n781
XU797 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n242 ZN=n403 A2=n245
XU796 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n483 ZN=n716 A2=n728
XU793 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n268 ZN=n1961 A2=n267
XU792 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n241 ZN=n256 A1=n2503 A3=n240 A4=n471
XU790 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n949 ZN=n777 A2=n1980
XU785 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n696 A1=n708 ZN=n735
XU784 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n242 ZN=n696 A2=n1100
XU783 INVD0BWP7T $PINS ZN=n257 VSS=VSS VDD=VDD I=n617
XU782 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n617 A2=n1100
XU778 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n259 A2=n472
XU776 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n714 ZN=n748 A2=n624
XU775 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n242 ZN=n624 A2=n237
XU774 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n943 ZN=n808 A2=n236
XU769 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n737 ZN=n695 A2=n746
XU768 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n454 A2=n620 A1=n469 ZN=n241 C=n464
XU766 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n621 ZN=n469 A2=n2245
XU764 IND4D0BWP7T $PINS VSS=VSS A1=n718 VDD=VDD B1=n759 B2=n2324 B3=n738
+ ZN=n234
XU763 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n245 ZN=n738 A2=n746
XU758 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n692 ZN=n609 A2=n1953
XU757 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n1953 A2=n237
XU756 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n263 ZN=n692 A2=n472
XU755 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n398 ZN=n478
XU754 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n398 A2=n1100
XU753 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n268 ZN=n768 A2=n233
XU752 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n760 ZN=n1978
XU751 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n232 ZN=n760 A2=n267
XU750 INVD0BWP7T $PINS ZN=n267 VSS=VSS VDD=VDD I=n233
XU749 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<127> A2=rk0<31> Z=n233
XU748 INVD0BWP7T $PINS ZN=n232 VSS=VSS VDD=VDD I=n268
XU745 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1288 ZN=n230 A1=n759 A3=n619 A4=n229
XU744 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n453 ZN=n229 A2=n595
XU743 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n262 ZN=n595 A2=n1230
XU740 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n749 ZN=n262 A2=n1950
XU736 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n382 ZN=n453 A2=n473
XU735 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1100 ZN=n473 A2=n746
XU733 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n472 ZN=n382 A2=n2769
XU731 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n238 ZN=n697 A2=n396
XU730 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n396 A2=n705
XU729 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n242 ZN=n238 A2=n472
XU726 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n795 ZN=n708 A2=n1083
XU725 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n737 ZN=n714 A2=n263
XU723 IND3D1BWP7T $PINS VSS=VSS VDD=VDD B1=n783 ZN=n1964 A1=n1945 B2=n471
XU722 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n471 A2=n472
XU720 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n611 ZN=n1951
XU719 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n228 ZN=n611 A2=n705
XU718 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n615 ZN=n694 A2=n1047
XU717 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n739 ZN=n1945 A2=n699
XU716 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n237 ZN=n699 A2=n263
XU715 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n737 ZN=n739 A2=n935
XU712 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n621 ZN=n250 A2=n710
XU707 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n228 ZN=n618 A2=n472
XU706 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n594 A2=n1119
XU702 NR4D1BWP7T $PINS VSS=VSS A4=n942 VDD=VDD ZN=n226 A3=n381 A2=n1960 A1=n483
XU701 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1972 ZN=n942
XU700 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n1972 A2=n237
XU699 INVD0BWP7T $PINS ZN=n381 VSS=VSS VDD=VDD I=n703
XU698 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n386 ZN=n703 A2=n245
XU696 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n776 A2=n245
XU694 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n948 ZN=n483
XU693 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n237 ZN=n948 A2=n228
XU691 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n928 ZN=n405 A2=n454
XU689 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n472 ZN=n798 A2=n746
XU684 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n921 ZN=n604 A2=n621
XU683 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n734 A1=n452 ZN=n244
XU682 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1967 ZN=n734 A2=n593
XU675 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2196 ZN=n475 A2=n961
XU673 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n691 ZN=n452 A2=n757
XU672 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n237 ZN=n757 A2=n2769
XU668 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n737 ZN=n691 A2=n386
XU666 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2560 ZN=n925 A2=n1955
XU665 INVD1BWP7T $PINS ZN=n744 VSS=VSS VDD=VDD I=n479
XU1036 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n521 ZN=n523 A1=n522 A3=n520 A4=n519
XU1035 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n528 A1=n992 A3=n556 A2=n518
XU1030 IND4D1BWP7T $PINS VSS=VSS A1=n2060 VDD=VDD B1=n2159 B2=n509 B3=n508
+ ZN=n510
XU1029 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n509 A1=n840 A3=n506 A2=n507
XU1028 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n505 ZN=n2016 A2=n2008
XU1026 AN4D1BWP7T $PINS VSS=VSS A1=n503 VDD=VDD A2=n973 A3=n2293 A4=n1009
+ Z=n504
XU1025 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1004 ZN=n582 A2=n502
XU1013 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n478 ZN=n939 A2=n928
XU1009 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1973 ZN=n713 A2=n471
XU1007 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n738 ZN=n809 A2=n1218
XU1004 IND4D0BWP7T $PINS VSS=VSS A1=n480 VDD=VDD B1=n783 B2=n2313 B3=n757
+ ZN=n462
XU1002 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2324 ZN=n463 A2=n720
XU997 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1973 ZN=n457 A1=n696 A3=n714 A4=n947
XU993 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n701 B1=n455 B2=n1966 B3=n454
+ ZN=n456
XU992 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n1954 A1=n453 ZN=n927
XU987 XNR4D1BWP7T $PINS A1=n1786 A2=n1603 ZN=n770 A3=n1609 A4=n1885 VDD=VDD
+ VSS=VSS
XU984 IND4D0BWP7T $PINS VSS=VSS A1=n444 VDD=VDD B1=n660 B2=n443 B3=n442 ZN=n445
XU981 IND4D0BWP7T $PINS VSS=VSS A1=n898 VDD=VDD B1=n437 B2=n436 B3=n894 ZN=n438
XU980 IND4D0BWP7T $PINS VSS=VSS A1=n435 VDD=VDD B1=n901 B2=n434 B3=n1082
+ ZN=n440
XU977 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1907 A2=n426 A1=n681 ZN=n428
+ C=n652
XU975 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n422 ZN=n424 A1=n423 A3=n1089 A4=n420
XU974 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n422 A1=n640 A3=n419 A2=n899
XU973 OAI211D0BWP7T $PINS A2=n417 ZN=n419 A1=n418 B=n416 VDD=VDD C=n663 VSS=VSS
XU972 XNR4D0BWP7T $PINS A1=n769 A2=n1029 ZN=rout<123> A3=n1028 A4=n415 VDD=VDD
+ VSS=VSS
XU971 XOR4D0BWP7T $PINS A3=n1585 VDD=VDD A4=n414 VSS=VSS A1=n1603 A2=rin<91>
+ Z=n415
XU969 AOI31D2BWP7T $PINS B=n1978 ZN=n410 A1=n707 A2=n1980 VDD=VDD A3=n2142
+ VSS=VSS
XU967 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2149 ZN=n408 A1=n2332 A3=n405
+ A4=n947
XU963 IND4D1BWP7T $PINS VSS=VSS A1=n730 VDD=VDD B1=n594 B2=n403 B3=n948 ZN=n404
XU962 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1091 ZN=n730 A2=n773
XU960 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n768 ZN=n1968
XU958 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n600 ZN=n399 A1=n959 A3=n398 A4=n1230
XU957 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1967 ZN=n600 A2=n718
XU953 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1091 ZN=n610 A2=n1047
XU952 INVD0BWP7T $PINS ZN=n797 VSS=VSS VDD=VDD I=n396
XU951 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n762 ZN=n601 A2=n2626
XU950 NR4D1BWP7T $PINS VSS=VSS A4=n754 VDD=VDD ZN=n401 A3=n726 A2=n1099 A1=n719
XU949 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n741 ZN=n754 A2=n1975
XU948 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n965 ZN=n1975 A2=n724
XU946 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n742 ZN=n1947
XU942 INVD1BWP7T $PINS ZN=n597 VSS=VSS VDD=VDD I=n750
XU941 AN4D1BWP7T $PINS VSS=VSS A1=n959 VDD=VDD A2=n394 A3=n2311 A4=n771 Z=n1981
XU939 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n695 ZN=n392 A2=n2322
XU937 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n699 ZN=n791
XU934 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1973 ZN=n388 A1=n949 A3=n701 A4=n624
XU933 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n594 ZN=n389 A2=n2308
XU932 IND3D1BWP7T $PINS VSS=VSS VDD=VDD B1=n696 ZN=n606 A1=n592 B2=n771
XU928 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n961 ZN=n806 A2=n2560
XU925 NR4D1BWP7T $PINS VSS=VSS A4=n464 VDD=VDD ZN=n383 A3=n965 A2=n1960
+ A1=n1952
XU924 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n702 ZN=n965
XU923 INVD0BWP7T $PINS ZN=n1952 VSS=VSS VDD=VDD I=n382
XU918 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n396 ZN=n711 A2=n618
XU912 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n503 ZN=n373 A1=n2024 A3=n372 A4=n371
XU911 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n996 ZN=n371 A2=n370
XU910 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n369 ZN=n503 A2=n535
XU908 CKND1BWP7T $PINS ZN=n1013 VSS=VSS VDD=VDD I=n521
XU906 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n364 ZN=n365 A1=n983 A3=n565 A4=n559
XU905 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n529 ZN=n559 A2=n363
XU899 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2275 ZN=n831 A2=n841
XU898 INVD0BWP7T $PINS ZN=n841 VSS=VSS VDD=VDD I=n354
XU895 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n352 ZN=n1010 A1=n520
XU892 OAI211D1BWP7T $PINS A2=n525 ZN=n349 A1=n355 B=n2011 VDD=VDD C=n828
+ VSS=VSS
XU888 NR4D1BWP7T $PINS VSS=VSS A4=n343 VDD=VDD ZN=n344 A3=n2031 A2=n500 A1=n564
XU885 INVD0BWP7T $PINS ZN=n339 VSS=VSS VDD=VDD I=n514
XU884 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1 ZN=n562 A2=n2038
XU883 INVD0BWP7T $PINS ZN=n2038 VSS=VSS VDD=VDD I=n827
XU878 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1814 A2=n2084 Z=n769
XU874 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n324 ZN=n325 A1=n436 A3=n323 A4=n1082
XU873 NR4D0BWP7T $PINS VSS=VSS A4=n1995 VDD=VDD ZN=n323 A3=n871 A2=n430 A1=n322
XU871 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n653 ZN=n434 A2=n319
XU870 INVD0BWP7T $PINS ZN=n871 VSS=VSS VDD=VDD I=n318
XU868 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n862 ZN=n316 A1=n666 A3=n315 A4=n314
XU867 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n862 A1=n313 A3=n312 A2=n1889
XU866 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n311 ZN=n666 A2=n1896
XU862 INVD0BWP7T $PINS ZN=n307 VSS=VSS VDD=VDD I=n644
XU860 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1053 ZN=n880 A2=n301
XU855 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n288 ZN=n429 A2=n899
XU850 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2315 ZN=n282 A1=n1924 A3=n2300
+ A4=n280
XU846 XNR4D2BWP7T $PINS A1=n1033 A2=n1936 ZN=rout<124> A3=n274 A4=n2601 VDD=VDD
+ VSS=VSS
XU843 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n268 ZN=n742 A2=n267
XU842 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2332 ZN=n269 A1=n1316 A3=n1949
+ A4=n266
XU841 AN4D1BWP7T $PINS VSS=VSS A1=n691 VDD=VDD A2=n723 A3=n722 A4=n721 Z=n266
XU839 OAI211D1BWP7T $PINS A2=n794 ZN=n265 A1=n911 B=n611 VDD=VDD C=n1270
+ VSS=VSS
XU837 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1972 ZN=n726 A2=n947
XU836 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n263 ZN=n947 A2=n705
XU835 INVD1BWP7T $PINS ZN=n607 VSS=VSS VDD=VDD I=n618
XU834 INVD0BWP7T $PINS ZN=n380 VSS=VSS VDD=VDD I=n692
XU831 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n915 ZN=n720 A2=n1119
XU824 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n935 ZN=n750 A2=n472
XU821 AOI22D0BWP7T $PINS B1=n930 A2=n256 ZN=n272 A1=n768 VDD=VDD B2=n255
+ VSS=VSS
XU1203 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1053 ZN=n861 A2=n900
XU1202 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2069 A2=n1785 Z=n2079
XU1196 IND4D0BWP7T $PINS VSS=VSS A1=n838 VDD=VDD B1=n837 B2=n836 B3=n835
+ ZN=n839
XU1193 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n991 ZN=n830 A1=n974 A3=n828 A4=n827
XU1190 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n984 ZN=n822 A1=n821 A3=n820 A4=n819
XU1189 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n996 ZN=n820 A2=n664
XU1186 IINR4D0BWP7T $PINS VSS=VSS A1=n967 VDD=VDD ZN=n812 B1=n811 B2=n810
+ A2=n957
XU1185 IND4D0BWP7T $PINS VSS=VSS A1=n809 VDD=VDD B1=n808 B2=n948 B3=n2324
+ ZN=n810
XU1182 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n799 ZN=n801 A1=n800 A3=n2324
+ A4=n798
XU1181 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n947 B1=n797 B2=n796 B3=n1950
+ ZN=n799
XU1178 INVD0BWP7T $PINS ZN=n950 VSS=VSS VDD=VDD I=n790
XU1176 NR4D0BWP7T $PINS VSS=VSS A4=n785 VDD=VDD ZN=n788 A3=n786 A2=n2345
+ A1=n803
XU1175 INVD0BWP7T $PINS ZN=n803 VSS=VSS VDD=VDD I=n784
XU1174 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n783 B1=n1099 B2=n781 B3=n809
+ ZN=n789
XU1171 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2153 ZN=n786 A2=n776
XU1170 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n775 ZN=n1944 A2=n1267
XU1169 OA21D0BWP7T $PINS Z=n775 A1=n773 VDD=VDD A2=n772 VSS=VSS B=n771
XU1168 XNR4D0BWP7T $PINS A1=n1036 A2=n1638 ZN=rout<114> A3=rin<82> A4=n770
+ VDD=VDD VSS=VSS
XU1167 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n769 A2=n916 ZN=n1036
XU1166 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2097 A2=n1813 ZN=n916
XU1162 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n758 ZN=n761 A1=n759 A3=n948 A4=n757
XU1161 NR4D0BWP7T $PINS VSS=VSS A4=n754 VDD=VDD ZN=n758 A3=n932 A2=n755
+ A1=n2325
XU1160 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n752 ZN=n932 A1=n753 A3=n751 A4=n750
XU1158 AOI31D1BWP7T $PINS B=n744 ZN=n752 A1=n921 A2=n746 VDD=VDD A3=n745
+ VSS=VSS
XU1157 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n742 ZN=n764 A3=n2724 A2=n934
+ A1=n1958
XU1155 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n735 A2=n736 A1=n737 ZN=n740
+ C=n933
XU1154 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n734 ZN=n933 A2=n733
XU1150 IND4D0BWP7T $PINS VSS=VSS A1=n724 VDD=VDD B1=n723 B2=n722 B3=n721
+ ZN=n725
XU1147 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2153 ZN=n717 A1=n716 A3=n715
+ A4=n714
XU1141 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n771 ZN=n704 A1=n703 A3=n702 A4=n701
XU1140 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n700 ZN=n1959 A2=n699
XU1139 NR4D0BWP7T $PINS VSS=VSS A4=n697 VDD=VDD ZN=n700 A3=n790 A2=n778 A1=n698
XU1138 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n696 A1=n750 ZN=n790 A3=n695
XU1137 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n694 ZN=n753 A2=n693
XU1136 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n692 ZN=n693 A1=n776 A3=n691 A4=n723
XU1135 XNR4D0BWP7T $PINS A1=n690 A2=n912 ZN=rout<115> A3=n689 A4=n1559 VDD=VDD
+ VSS=VSS
XU1134 XNR4D0BWP7T $PINS A1=n2084 A2=n1603 ZN=n689 A3=rin<83> A4=n1023 VDD=VDD
+ VSS=VSS
XU1131 XNR3D2BWP7T $PINS A1=n2723 A2=n1935 VDD=VDD VSS=VSS A3=n687 ZN=rout<116>
XU1130 XNR4D0BWP7T $PINS A1=n1603 A2=n690 ZN=n687 A3=rin<84> A4=n919 VDD=VDD
+ VSS=VSS
XU1129 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1025 A2=n686 Z=n919
XU1125 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n901 ZN=n679 A1=n678 A3=n677 A4=n676
XU1123 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n673 ZN=n857 A2=n672
XU1120 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n665 ZN=n671 A1=n666 A3=n2300
+ A4=n663
XU1118 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n659 ZN=n661 A1=n660 A3=n663
+ A4=n1082
XU1115 AO211D0BWP7T $PINS Z=n662 C=n648 B=n649 A2=n650 VDD=VDD A1=n1108 VSS=VSS
XU1113 OAI211D0BWP7T $PINS A2=n111 ZN=n646 A1=n644 B=n642 VDD=VDD C=n641
+ VSS=VSS
XU1112 NR4D0BWP7T $PINS VSS=VSS A4=n1995 VDD=VDD ZN=n641 A3=n639 A2=n899
+ A1=n640
XU1111 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2285 ZN=n639 A2=n1910
XU1103 OAI211D1BWP7T $PINS A2=n772 ZN=n628 A1=n1047 B=n784 VDD=VDD C=n627
+ VSS=VSS
XU1102 NR4D1BWP7T $PINS VSS=VSS A4=n626 VDD=VDD ZN=n627 A3=n1945 A2=n1099
+ A1=n942
XU1101 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n695 ZN=n626 A2=n771
XU1100 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2325 ZN=n784 A2=n625
XU1099 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1230 ZN=n625 A1=n624 A3=n1267
+ A4=n1270
XU1097 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n621 ZN=n772 A2=n620
XU1095 NR4D0BWP7T $PINS VSS=VSS A4=n616 VDD=VDD ZN=n632 A3=n711 A2=n726 A1=n934
XU1093 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n612 ZN=n934 A2=n611
XU1089 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n604 ZN=n1946 A2=n1047
XU1088 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n603 ZN=n780 A2=n602
XU1087 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n600 ZN=n602 A1=n601 A3=n703 A4=n722
XU1084 INVD0BWP7T $PINS ZN=n709 VSS=VSS VDD=VDD I=n771
XU1083 AN4D1BWP7T $PINS VSS=VSS A1=n594 VDD=VDD A2=n1972 A3=n783 A4=n800 Z=n599
XU1082 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n698 ZN=n800 A2=n593
XU1080 INVD0BWP7T $PINS ZN=n733 VSS=VSS VDD=VDD I=n713
XU1076 IIND4D0BWP7T $PINS VSS=VSS A1=n584 VDD=VDD ZN=n585 B1=n826 B2=n985
+ A2=n2021
XU1072 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n843 A1=n982 ZN=n576 A3=n835
XU1071 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n579 ZN=n835 A2=n575
XU1070 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2004 ZN=n982 A2=n574
XU1068 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n569 A2=n570 A1=n571 ZN=n572
+ C=n568
XU1067 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n565 A1=n2265 ZN=n568 A2=n566
XU1064 AN4D1BWP7T $PINS VSS=VSS A1=n559 VDD=VDD A2=n2042 A3=n984 A4=n558 Z=n560
XU1062 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n561 A1=n564 A3=n978 A2=n1014
XU1061 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n555 ZN=n978 A2=n554
XU1060 INVD0BWP7T $PINS ZN=n1014 VSS=VSS VDD=VDD I=n553
XU1059 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n552 ZN=n836 A2=n584
XU1058 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1018 ZN=n584 A2=n2009
XU1057 XNR4D2BWP7T $PINS A1=n770 A2=rin<90> ZN=rout<122> A3=n1023 A4=n8 VDD=VDD
+ VSS=VSS
XU1052 OAI211D2BWP7T $PINS A2=n1015 ZN=n2064 A1=n2131 B=n2144 VDD=VDD C=n2148
+ VSS=VSS
XU1050 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n542 ZN=n545 A1=n543 A3=n2006
+ A4=n2033
XU1049 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2278 ZN=n547 A1=n2294 A3=n990
+ A4=n989
XU1046 IND4D1BWP7T $PINS VSS=VSS A1=n823 VDD=VDD B1=n834 B2=n538 B3=n537
+ ZN=n539
XU1045 NR4D1BWP7T $PINS VSS=VSS A4=n534 VDD=VDD ZN=n537 A3=n1004 A2=n535
+ A1=n536
XU1043 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n531 ZN=n823 A2=n2011
XU1042 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n529 A2=n530 A1=n664 ZN=n531
+ C=n2067
XU1041 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n528 ZN=n540 A1=n826 A3=n527 A4=n986
XU1040 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n526 ZN=n986 A2=n731
XU1039 NR4D0BWP7T $PINS VSS=VSS A4=n1012 VDD=VDD ZN=n527 A3=n574 A2=n824 A1=n1
XU1038 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n997 ZN=n574 A2=n524
XU1037 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n523 ZN=n997 A1=n583
XU1426 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1257 ZN=n1395 A2=n1237
XU1425 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1237 A2=n1413
XU1424 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1446 ZN=n1257 A2=n638
XU1421 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1567 A2=n684 A1=n1055 ZN=n1056
+ C=n1287
XU1418 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1231 ZN=n1364 A2=n1563
XU1417 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n517 ZN=n1266 A2=n1413
XU1415 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1482 ZN=n1836
XU1411 NR4D1BWP7T $PINS VSS=VSS A4=n1550 VDD=VDD ZN=n1051 A3=n1353 A2=n1392
+ A1=n1828
XU1410 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1420 ZN=n1550
XU1405 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n517 ZN=n1457 A2=n638
XU1404 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n1475 ZN=n1227 A1=n1538
XU1399 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1843 ZN=n1240 A2=n1796
XU1398 INVD0BWP7T $PINS ZN=n1284 VSS=VSS VDD=VDD I=n1298
XU1395 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n638 ZN=n1848 A2=n541
XU1394 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1555 ZN=n1403 A2=n1470
XU1393 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1253 ZN=n1470 A2=n1241
XU1392 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1217 ZN=n1555 A2=n495
XU1390 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1286 A1=n1068 A3=n1193 A2=n1373
XU1387 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1823 ZN=n1542 A2=n1228
XU1386 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1228 A2=n460
XU1384 INVD1BWP7T $PINS ZN=n1373 VSS=VSS VDD=VDD I=n1833
XU1381 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1043 ZN=n1282 A2=n1578
XU1380 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1578 A2=n608
XU1378 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n476 ZN=n1058 A2=n1071
XU1375 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1251 ZN=n1225 A2=n1533
XU1374 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n1406 ZN=n1533
XU1373 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n517 ZN=n1406 A2=n460
XU1370 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n1380 ZN=n1569 A1=n1279 B2=n1042
XU1368 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1242 ZN=n1432
XU1367 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1253 ZN=n1242 A2=n638
XU1363 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1066 ZN=n1479
XU1362 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1066 A2=n638
XU1359 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1055 ZN=n1562 A2=n427
XU1356 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1068 ZN=n1222 A2=n1828
XU1353 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n118 ZN=n1799 A2=n474
XU1350 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1795 ZN=n1072 A2=n1287
XU1345 CKND0BWP7T $PINS ZN=n1795 VSS=VSS VDD=VDD I=n1294
XU1344 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1294 A2=n1217
XU1343 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1807 A2=n1551 A1=n1236
XU1342 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1561 ZN=n1551
XU1341 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n495 ZN=n1561 A2=n608
XU1334 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n474 ZN=n1548 A2=n638
XU1332 IIND4D1BWP7T $PINS VSS=VSS A1=n1843 VDD=VDD ZN=n1039 B1=n1819 B2=n1833
+ A2=n1350
XU1331 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1253 ZN=n1833 A2=n1217
XU1329 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1231 ZN=n1253
XU1328 INR2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n1429 ZN=n1819 A1=n1393
XU1324 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n118 ZN=n1393 A2=n495
XU1323 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1823 ZN=n1350 A2=n2259
XU1318 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1038 ZN=n1040 A2=n1462
XU1317 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n474 ZN=n1823 A2=n460
XU1311 AN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n1843 A2=n495 A1=n638
XU1306 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n367 ZN=n1375 A2=n402
XU1304 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1538 ZN=n1073 A2=n1831
XU1303 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1831 A2=n1241
XU1300 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1246 ZN=n1538 A2=n541
XU1296 INVD1BWP7T $PINS ZN=n1038 VSS=VSS VDD=VDD I=n1245
XU1295 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1478 ZN=n1420 A2=n1842
XU1280 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1414 ZN=n1357 A2=n1439
XU1277 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<36> A2=n140 ZN=n1245
XU1274 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2193 ZN=n1824 A2=n1075
XU1271 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<38> A2=rk1<6> Z=n1076
XU1270 XNR4D2BWP7T $PINS A1=n1036 A2=rin<66> ZN=rout<98> A3=n1452 A4=n1035
+ VDD=VDD VSS=VSS
XU1269 XNR3D2BWP7T $PINS A1=n1034 A2=n1033 VDD=VDD VSS=VSS A3=n1032 ZN=rout<99>
XU1268 XNR4D0BWP7T $PINS A1=n2097 A2=n1031 ZN=n1032 A3=n1494 A4=rin<67> VDD=VDD
+ VSS=VSS
XU1267 XNR3D2BWP7T $PINS A1=n1989 A2=n1034 VDD=VDD VSS=VSS A3=n1030
+ ZN=rout<100>
XU1266 XNR4D0BWP7T $PINS A1=n1029 A2=n1682 ZN=n1030 A3=n1028 A4=rin<68> VDD=VDD
+ VSS=VSS
XU1263 XNR4D0BWP7T $PINS A1=rin<74> A2=n1024 ZN=rout<106> A3=n1035 A4=n1023
+ VDD=VDD VSS=VSS
XU1262 XNR3D0BWP7T $PINS A1=n2691 A2=n1434 VDD=VDD VSS=VSS A3=n2079 ZN=n1035
XU1258 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1010 ZN=n1011 A1=n2010 A3=n1009
+ A4=n2034
XU1251 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n988 ZN=n2010 A2=n987
XU1250 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n986 ZN=n987 A1=n2013 A3=n985
+ A4=n984
XU1236 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1100 ZN=n937 A2=n2769
XU1235 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n965 ZN=n938 A2=n964
XU1234 INVD0BWP7T $PINS ZN=n945 VSS=VSS VDD=VDD I=n934
XU1233 OA31D0BWP7T $PINS Z=n972 B=n930 A3=n931 A2=n932 A1=n933 VDD=VDD VSS=VSS
XU1232 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n926 A3=n927 A2=n928 A1=n929 Z=n931
XU1229 XNR4D0BWP7T $PINS A1=n919 A2=n918 ZN=rout<107> A3=rin<75> A4=n917
+ VDD=VDD VSS=VSS
XU1227 INVD0BWP7T $PINS ZN=n1027 VSS=VSS VDD=VDD I=n2079
XU1224 XNR4D2BWP7T $PINS A1=n2079 A2=n1638 ZN=rout<108> A3=n1826 A4=n913
+ VDD=VDD VSS=VSS
XU1223 XNR4D0BWP7T $PINS A1=n912 A2=rin<76> ZN=n913 A3=n1559 A4=n1988 VDD=VDD
+ VSS=VSS
XU1219 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n904 ZN=n906 A1=n905 A3=n903 A4=n902
XU1218 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n901 B1=n900 B2=n899 B3=n898
+ ZN=n902
XU1213 IND3D1BWP7T $PINS VSS=VSS VDD=VDD B1=n897 ZN=n883 A1=n882 B2=n881
XU1212 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2703 ZN=n893 A1=n880 A3=n1925
+ A4=n879
XU1211 AN4D1BWP7T $PINS VSS=VSS A1=n1909 VDD=VDD A2=n878 A3=n877 A4=n876 Z=n879
XU1206 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n862 ZN=n864 A1=n863 A3=n861 A4=n860
XU1624 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1195 ZN=n1179 A2=n1752
XU1623 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1113 ZN=n1752 A2=n910
XU1622 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n658 ZN=n1195 A2=n1141
XU1619 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1097 A1=n1497 ZN=n1112 A3=n1313
XU1618 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1691 ZN=n1313 A2=n658
XU1615 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1697 ZN=n1597 A2=n1126
XU1612 AN3D1BWP7T $PINS VSS=VSS A1=n2305 VDD=VDD A2=n960 A3=n1096 Z=n1497
XU1608 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1771 ZN=n1623
XU1606 NR4D1BWP7T $PINS VSS=VSS A4=n1094 VDD=VDD ZN=n1121 A3=n1601 A2=n1729
+ A1=n1159
XU1605 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1737 ZN=n1094 A1=n1733 A3=n2273
+ A4=n1138
XU1604 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1107 ZN=n1138 A2=n807
XU1600 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1700 A2=n1141
XU1598 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1109 A2=n958 A1=n1628 ZN=n1093
+ C=n1160
XU1597 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1306 ZN=n1160 A2=n1610
XU1596 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1750 ZN=n1610 A2=n680
XU1595 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1306 A2=n1113
XU1594 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2253 ZN=n1109 A2=n2237
XU1591 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1177 ZN=n1156 A2=n1110
XU1589 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n958 ZN=n1186 A2=n680
XU1587 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n792 ZN=n1732 A2=n747
XU1586 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1691 ZN=n1595 A2=n1201
XU1585 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1312 ZN=n1159 A2=n1152
XU1584 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1637 ZN=n1152 A2=n1765
XU1583 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1312 A1=n2093 A3=n1758 A2=n1762
XU1582 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1096 ZN=n1758 A1=n1129 A3=n1507
+ A4=n1125
XU1577 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n1670 A1=n1608 ZN=n1666
XU1576 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1691 ZN=n1670 A2=n807
XU1575 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1766 ZN=n1096 A2=n1683
XU1573 INVD0BWP7T $PINS ZN=n1766 VSS=VSS VDD=VDD I=n1642
XU1571 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1336 ZN=n1705 A2=n1734
XU1568 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1602 ZN=n1336 A2=n1090
XU1567 IND4D0BWP7T $PINS VSS=VSS A1=n1736 VDD=VDD B1=n1607 B2=n1129 B3=n1643
+ ZN=n1090
XU1566 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1163 ZN=n1643 A2=n807
XU1563 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1203 A2=n1134 A1=n1192
XU1561 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n807 ZN=n1612 A2=n747
XU1558 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2272 ZN=n1192 A2=n2237
XU1554 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n923 ZN=n1733 A2=n1321
XU1553 INVD0BWP7T $PINS ZN=n1321 VSS=VSS VDD=VDD I=n1198
XU1552 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1141 ZN=n1198 A2=n792
XU1550 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n658 ZN=n1671 A2=n1113
XU1544 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1177 ZN=n1602 A2=n1153
XU1543 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n683 ZN=n1153 A2=n1750
XU1541 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n958 ZN=n1177 A2=n1691
XU1539 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1675 ZN=n1727
XU1538 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n441 ZN=n1675 A2=n1117
XU1533 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n792 ZN=n1746 A2=n1107
XU1531 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1184 A2=n680
XU1529 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1087 ZN=n1524 A2=n1664
XU1528 NR4D0BWP7T $PINS VSS=VSS A4=n1662 VDD=VDD ZN=n1088 A3=n1764 A2=n1204
+ A1=n1667
XU1526 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1628 ZN=n1172 A2=n1315
XU1522 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1318 ZN=n1667 A2=n1523
XU1515 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1110 ZN=n1704 A2=n1642
XU1514 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1201 ZN=n1642 A2=n680
XU1511 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n658 ZN=n1110 A2=n1163
XU1509 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1751 ZN=n1697
XU1508 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1304 ZN=n1751 A2=n1717
XU1507 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1611 ZN=n1599 A2=n1323
XU1506 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n658 ZN=n1323 A2=n680
XU1503 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1107 ZN=n1611 A2=n910
XU1497 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1087 ZN=n1085 A2=n2211
XU1493 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1618 ZN=n1142 A2=n467
XU1489 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1717 ZN=n1086 A2=n2203
XU1487 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1304 ZN=n1680 A2=n1315
XU1484 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1722 ZN=n1616 A2=n1304
XU1483 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1690 ZN=n1681 A2=n407
XU1479 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<53> A2=rk1<21> Z=n1087
XU1475 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1722 A2=n1315 A1=n1717
XU1465 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n474 ZN=n1463 A2=n608
XU1460 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1453 A2=n1413
XU1456 INVD0BWP7T $PINS ZN=n1351 VSS=VSS VDD=VDD I=n1415
XU1454 INVD0BWP7T $PINS ZN=n1248 VSS=VSS VDD=VDD I=n1257
XU1453 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1236 ZN=n1817 A2=n1535
XU1449 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1062 ZN=n1063 A1=n1354 A3=n1235
+ A4=n1265
XU1448 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1253 ZN=n1265 A2=n460
XU1447 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1413 ZN=n1235 A2=n495
XU1446 OA31D0BWP7T $PINS Z=n1062 B=n1070 A3=n1347 A2=n1374 A1=n402 VDD=VDD
+ VSS=VSS
XU1443 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1217 ZN=n1469 A2=n1273
XU1442 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n1798 ZN=n1822
XU1441 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1798 A2=n118
XU1440 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1570 ZN=n1354 A2=n1059
XU1439 IND4D0BWP7T $PINS VSS=VSS A1=n1417 VDD=VDD B1=n1799 B2=n2256 B3=n1456
+ ZN=n1059
XU1435 INVD0BWP7T $PINS ZN=n1570 VSS=VSS VDD=VDD I=n1228
XU1434 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1848 ZN=n1064 A1=n1293 A3=n1477
+ A4=n1415
XU1433 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1413 ZN=n1415 A2=n541
XU1432 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1226 ZN=n1477
XU1429 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n517 ZN=n1430 A2=n1241
XU1428 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1558 A2=n460
XU1799 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1848 ZN=n1256 A2=n1831
XU1798 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1232 ZN=n1281 A2=n1294
XU1797 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1817 B1=n1576 B2=n1428 B3=n1840
+ ZN=n1232
XU1796 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1840 A2=n1577 A1=n1794
XU1789 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1578 ZN=n1544
XU1788 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1225 ZN=n1239 A2=n1224
XU1787 NR4D1BWP7T $PINS VSS=VSS A4=n1397 VDD=VDD ZN=n1224 A3=n1388 A2=n1223
+ A1=n1445
XU1783 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1574 A2=n1822 A1=n1460
XU1782 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2241 ZN=n1460 A2=n2258
XU1780 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1579 ZN=n1269 A2=n1812
XU1778 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1217 ZN=n1366 A2=n517
XU1777 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n439 ZN=n1219 A2=n1357
XU1775 IND2D1BWP7T $PINS VSS=VSS VDD=VDD B1=n936 A1=n1473 ZN=n1416
XU1772 INVD1BWP7T $PINS ZN=n1223 VSS=VSS VDD=VDD I=n1265
XU1768 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2663 ZN=n1720 A2=n1752
XU1767 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2327 ZN=n1743 A2=n1210
XU1763 AOI21D0BWP7T $PINS VSS=VSS A2=n1205 VDD=VDD A1=n1739 B=n1675 ZN=n1213
XU1762 NR4D1BWP7T $PINS VSS=VSS A4=n1337 VDD=VDD ZN=n1205 A3=n1634 A2=n1203
+ A1=n1204
XU1761 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1687 A1=n1734 ZN=n1337 A3=n1202
XU1760 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1764 A2=n1722 A1=n1201 ZN=n1202
+ C=n1512
XU1759 INVD0BWP7T $PINS ZN=n1512 VSS=VSS VDD=VDD I=n1699
XU1758 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1200 ZN=n1687
XU1756 AN4D1BWP7T $PINS VSS=VSS A1=n1319 VDD=VDD A2=n1732 A3=n1684 A4=n1737
+ Z=n1199
XU1751 IND4D0BWP7T $PINS VSS=VSS A1=n1765 VDD=VDD B1=n1701 B2=n1645 B3=n1190
+ ZN=n1191
XU1750 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1749 ZN=n1645 A2=n1189
XU1749 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1187 A1=n1188 ZN=n1200 A3=n1186
XU1748 NR4D0BWP7T $PINS VSS=VSS A4=n1518 VDD=VDD ZN=n1187 A3=n1735 A2=n1763
+ A1=n1185
XU1747 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1184 ZN=n1763
XU1737 OAI211D1BWP7T $PINS A2=n1524 ZN=n1173 A1=n1172 B=n1630 VDD=VDD C=n1322
+ VSS=VSS
XU1736 INVD0BWP7T $PINS ZN=n1630 VSS=VSS VDD=VDD I=n1327
XU1735 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1643 ZN=n1327 A2=n1186
XU1732 INVD0BWP7T $PINS ZN=n1311 VSS=VSS VDD=VDD I=n1171
XU1731 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1719 A2=n1938 Z=n1871
XU1729 AOI21D2BWP7T $PINS VSS=VSS A2=n1986 VDD=VDD A1=n1166 B=n1623 ZN=n1167
XU1728 NR4D1BWP7T $PINS VSS=VSS A4=n1164 VDD=VDD ZN=n1165 A3=n1339 A2=n1694
+ A1=n2627
XU1727 AO211D0BWP7T $PINS Z=n1164 C=n1614 B=n2321 A2=n1690 VDD=VDD A1=n1163
+ VSS=VSS
XU1723 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1749 ZN=n1740 A2=n1505
XU1722 INVD0BWP7T $PINS ZN=n1516 VSS=VSS VDD=VDD I=n1160
XU1721 INVD0BWP7T $PINS ZN=n1166 VSS=VSS VDD=VDD I=n1159
XU1717 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1612 ZN=n1155 A1=n1153 A3=n2288
+ A4=n1313
XU1715 INVD0BWP7T $PINS ZN=n1320 VSS=VSS VDD=VDD I=n1152
XU1712 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n960 ZN=n1150 A1=n2252 A3=n1700
+ A4=n1670
XU1709 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1330 B1=n1608 B2=n1505 B3=n1621
+ ZN=n1149
XU1707 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n683 ZN=n1330 A2=n1718
XU1705 AOI21D2BWP7T $PINS VSS=VSS A2=n1146 VDD=VDD A1=n1147 B=n2210 ZN=n1169
XU1703 NR4D1BWP7T $PINS VSS=VSS A4=n1145 VDD=VDD ZN=n1146 A3=n1171 A2=n1773
+ A1=n2743
XU1701 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1636 A2=n1141 A1=n1142 ZN=n1144
+ C=n922
XU1699 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1679 ZN=n1171 A2=n1140
XU1697 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1184 ZN=n1504 A2=n1138
XU1695 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1615 A2=n747
XU1694 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1136 ZN=n1773 A2=n1135
XU1693 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1181 B1=n1134 B2=n1151 B3=n1622
+ ZN=n1136
XU1691 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1691 ZN=n1181 A2=n1718
XU1690 INVD0BWP7T $PINS ZN=n1147 VSS=VSS VDD=VDD I=n1133
XU1689 AOI21D2BWP7T $PINS VSS=VSS A2=n2740 VDD=VDD A1=n1502 B=n1708 ZN=n1170
XU1687 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1724 ZN=n1130 A1=n1129 A3=n1684
+ A4=n1731
XU1686 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1163 ZN=n1731 A2=n910
XU1685 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n792 ZN=n1724 A2=n1163
XU1684 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1596 ZN=n1131 A1=n2255 A3=n1135
+ A4=n1180
XU1683 INVD1BWP7T $PINS ZN=n1596 VSS=VSS VDD=VDD I=n1189
XU1680 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n868 ZN=n1621 A2=n1681
XU1679 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1133 ZN=n1502 A2=n1128
XU1678 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1127 ZN=n1128 A1=n1679 A3=n1313
+ A4=n1610
XU1677 NR4D0BWP7T $PINS VSS=VSS A4=n1510 VDD=VDD ZN=n1127 A3=n1635 A2=n1050
+ A1=n1674
XU1673 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1124 ZN=n1133 A2=n1319
XU1672 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1595 B1=n923 B2=n2080 B3=n1197
+ ZN=n1124
XU1665 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1113 ZN=n1180 A2=n1201
XU1664 NR4D0BWP7T $PINS VSS=VSS A4=n1111 VDD=VDD ZN=n1114 A3=n1112 A2=n1185
+ A1=n1309
XU1663 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1746 ZN=n1111 A1=n1331 A3=n2273
+ A4=n1186
XU1662 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1134 ZN=n1331 A2=n1736
XU1661 INVD0BWP7T $PINS ZN=n1185 VSS=VSS VDD=VDD I=n1323
XU1660 INVD1BWP7T $PINS ZN=n1309 VSS=VSS VDD=VDD I=n1110
XU1659 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1190 ZN=n1673 A2=n1679
XU1657 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1515 ZN=n1511
XU1656 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n658 ZN=n1515 A2=n747
XU1655 INVD0BWP7T $PINS ZN=n1190 VSS=VSS VDD=VDD I=n1109
XU1653 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n683 ZN=n1684 A2=n910
XU1651 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1188 A2=n1154 A1=n1322
XU1650 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1141 ZN=n1154 A2=n807
XU1649 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1322 A2=n1107
XU1648 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1700 ZN=n1335 A1=n1755 A3=n1732
+ A4=n1699
XU1646 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1755 A2=n1135 A1=n1161
XU1645 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n958 ZN=n1135 A2=n1113
XU1644 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1741 A1=n1620 ZN=n1120 A2=n1106
XU1642 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1117 ZN=n1708 A2=n1116
XU1641 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1105 ZN=n1106 A1=n163 A3=n1671
+ A4=n2087
XU1640 NR4D0BWP7T $PINS VSS=VSS A4=n1520 VDD=VDD ZN=n1105 A3=n1492 A2=n1189
+ A1=n1498
XU1638 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1750 ZN=n1319 A2=n1107
XU1637 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1321 ZN=n1104 A2=n1749
XU1635 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1115 ZN=n1696 A2=n1614
XU1633 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2306 ZN=n1635 A2=n1161
XU1632 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1718 ZN=n1161 A2=n1163
XU1969 OAI211D1BWP7T $PINS A2=n1563 ZN=n1472 A1=n485 B=n1470 VDD=VDD C=n1469
+ VSS=VSS
XU1968 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1465 ZN=n1486 A3=n1466 A2=n1467
+ A1=n2319
XU1965 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1459 ZN=n1838 A2=n1458
XU1964 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1457 ZN=n1458 A1=n1819 A3=n1456
+ A4=n1455
XU1963 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1454 ZN=n1467 A1=n1546 A3=n1453
+ A4=n2222
XU1962 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1487 A1=n1451 A3=n1449 A2=n1450
XU1960 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n2088 A2=n1446 A1=n1830 ZN=n1447
+ C=n1827
XU1958 NR4D1BWP7T $PINS VSS=VSS A4=n1440 VDD=VDD ZN=n1442 A3=n1844 A2=n1441
+ A1=n1459
XU1955 NR4D0BWP7T $PINS VSS=VSS A4=n1431 VDD=VDD ZN=n1435 A3=n1473 A2=n1432
+ A1=n1433
XU1954 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1558 ZN=n1431 A2=n1430
XU1953 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1567 ZN=n1436 A2=n1566
XU1952 NR4D1BWP7T $PINS VSS=VSS A4=n1584 VDD=VDD ZN=n1443 A3=n1428 A2=n1575
+ A1=n1429
XU1948 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1419 ZN=n1421 A1=n1420 A3=n1444
+ A4=n4
XU1946 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1457 A1=n1477 ZN=n1422 A3=n1415
XU1944 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1409 ZN=n1411 A1=n1410 A3=n1408
+ A4=n1407
XU1943 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1477 A1=n1470 ZN=n1412 A3=n1406
XU1940 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1547 A1=n1401 ZN=n1835 A3=n1400
XU1939 NR4D1BWP7T $PINS VSS=VSS A4=n1840 VDD=VDD ZN=n1400 A3=n1542 A2=n1478
+ A1=n1428
XU1936 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n2259 ZN=n1568 A1=n1395 B2=n1538
XU1935 AN4D1BWP7T $PINS VSS=VSS A1=n1470 VDD=VDD A2=n1477 A3=n1393 A4=n1456
+ Z=n1399
XU1933 IND4D1BWP7T $PINS VSS=VSS A1=n1390 VDD=VDD B1=n1389 B2=n1560 B3=n1548
+ ZN=n1391
XU1932 NR4D1BWP7T $PINS VSS=VSS A4=n1387 VDD=VDD ZN=n1389 A3=n1388 A2=n1551
+ A1=n1567
XU1931 XNR4D2BWP7T $PINS A1=n1715 A2=n1871 ZN=rout<60> A3=n1784 A4=n1386
+ VDD=VDD VSS=VSS
XU1930 XNR4D0BWP7T $PINS A1=sout1<28> A2=n1627 ZN=n1386 A3=n1873 A4=rin<28>
+ VDD=VDD VSS=VSS
XU1923 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1376 ZN=n1378 A1=n1377 A3=n1408
+ A4=n2257
XU1919 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1454 ZN=n1370 A1=n1369 A3=n1409
+ A4=n1444
XU1916 INVD0BWP7T $PINS ZN=n1455 VSS=VSS VDD=VDD I=n1364
XU1910 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1560 A2=n638
XU1909 NR4D0BWP7T $PINS VSS=VSS A4=n1575 VDD=VDD ZN=n1356 A3=n1576 A2=n1828
+ A1=n1843
XU1908 CKND0BWP7T $PINS ZN=n1575 VSS=VSS VDD=VDD I=n1463
XU1907 INVD0BWP7T $PINS ZN=n1484 VSS=VSS VDD=VDD I=n1354
XU1902 INVD0BWP7T $PINS ZN=n1534 VSS=VSS VDD=VDD I=n1349
XU1900 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2128 A2=n2126 Z=n1784
XU1899 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2111 ZN=n2126
XU1898 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2617 A2=n1606 ZN=n2111
XU1895 OAI31D2BWP7T $PINS VSS=VSS VDD=VDD B=n1771 ZN=n1341 A3=n1338 A2=n1339
+ A1=n1340
XU1894 IND4D0BWP7T $PINS VSS=VSS A1=n1337 VDD=VDD B1=n1507 B2=n1595 B3=n1615
+ ZN=n1338
XU1893 INVD0BWP7T $PINS ZN=n1340 VSS=VSS VDD=VDD I=n1336
XU1891 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1206 ZN=n1334 A1=n1733 A3=n1332
+ A4=n1610
XU1890 IINR4D1BWP7T $PINS VSS=VSS A1=n1331 VDD=VDD ZN=n1332 B1=n1666 B2=n1693
+ A2=n1748
XU1889 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1330 ZN=n1693 A2=n1595
XU1887 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1599 ZN=n1500 A2=n1327
XU1886 NR4D1BWP7T $PINS VSS=VSS A4=n1325 VDD=VDD ZN=n1343 A3=n1326 A2=n1327
+ A1=n1527
XU1885 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1747 ZN=n1325 A1=n1206 A3=n1724
+ A4=n1615
XU1884 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1640 ZN=n1747 A2=n1324
XU1883 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1323 ZN=n1324 A1=n1503 A3=n2255
+ A4=n1322
XU1882 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1321 ZN=n1503 A2=n1320
XU1881 INVD0BWP7T $PINS ZN=n1640 VSS=VSS VDD=VDD I=n1319
XU1879 OAI211D1BWP7T $PINS A2=n868 ZN=n1326 A1=n1318 B=n1748 VDD=VDD C=n1650
+ VSS=VSS
XU1877 INVD0BWP7T $PINS ZN=n1314 VSS=VSS VDD=VDD I=n1610
XU1876 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1641 ZN=n1748 A2=n1721
XU1875 INVD0BWP7T $PINS ZN=n1721 VSS=VSS VDD=VDD I=n1684
XU1874 INVD0BWP7T $PINS ZN=n1641 VSS=VSS VDD=VDD I=n1313
XU1871 IND4D1BWP7T $PINS VSS=VSS A1=n1761 VDD=VDD B1=n2271 B2=n1596 B3=n1306
+ ZN=n1307
XU1864 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1393 ZN=n1295 A1=n2240 A3=n1294
+ A4=n1548
XU1862 INVD0BWP7T $PINS ZN=n1584 VSS=VSS VDD=VDD I=n1811
XU1859 OA21D0BWP7T $PINS Z=n1291 A1=n1290 VDD=VDD A2=n541 VSS=VSS B=n684
XU1858 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1376 A1=n1454 ZN=n1396 A3=n1401
XU1857 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1473 ZN=n1401 A2=n1841
XU1856 INVD0BWP7T $PINS ZN=n1841 VSS=VSS VDD=VDD I=n1365
XU1855 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1544 ZN=n1376 A2=n1287
XU1850 NR4D1BWP7T $PINS VSS=VSS A4=n1283 VDD=VDD ZN=n1285 A3=n1284 A2=n1822
+ A1=n1373
XU1849 IND4D1BWP7T $PINS VSS=VSS A1=n1282 VDD=VDD B1=n1823 B2=n1457 B3=n1463
+ ZN=n1283
XU1847 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1803 ZN=n1552 A2=n1812
XU1846 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1351 ZN=n1448 A2=n1280
XU1845 OAI211D1BWP7T $PINS A2=n1580 ZN=n1280 A1=n1374 B=n1454 VDD=VDD C=n1365
+ VSS=VSS
XU1843 AOI31D1BWP7T $PINS B=n1808 ZN=n1302 A1=n1546 A2=n1278 VDD=VDD A3=n1277
+ VSS=VSS
XU1841 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1457 ZN=n1275 A1=n1274 A3=n1463
+ A4=n1476
XU1840 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1476 A2=n1272
XU1839 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n402 ZN=n1272 A2=n439
XU1838 OAI211D1BWP7T $PINS A2=n1357 ZN=n1276 A1=n1375 B=n1298 VDD=VDD C=n1453
+ VSS=VSS
XU1837 INVD0BWP7T $PINS ZN=n1278 VSS=VSS VDD=VDD I=n1269
XU1835 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1266 ZN=n1268 A1=n936 A3=n1265
+ A4=n1430
XU1830 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1811 ZN=n1259 A1=n2303 A3=n1548
+ A4=n2222
XU1825 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n1810 ZN=n1450 A1=n1256 B2=n1255
XU1822 IND4D1BWP7T $PINS VSS=VSS A1=n1251 VDD=VDD B1=n1555 B2=n1265 B3=n1463
+ ZN=n1252
XU1821 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1490 A1=n1451 ZN=n1261 A2=n84
XU1820 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1816 ZN=n1250 A1=n1361 A3=n1249
+ A4=n1456
XU1819 NR4D0BWP7T $PINS VSS=VSS A4=n1296 VDD=VDD ZN=n1249 A3=n1794 A2=n1387
+ A1=n1248
XU1818 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1247 ZN=n1296 A2=n1477
XU1816 INVD0BWP7T $PINS ZN=n1387 VSS=VSS VDD=VDD I=n1453
XU1814 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n936 ZN=n1243 A1=n1470 A3=n1242
+ A4=n1365
XU1813 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1273 ZN=n1365 A2=n1241
XU1812 INVD1BWP7T $PINS ZN=n1402 VSS=VSS VDD=VDD I=n1240
XU1808 INVD0BWP7T $PINS ZN=n1536 VSS=VSS VDD=VDD I=n1237
XU1806 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1478 ZN=n1369 A2=n1549
XU1805 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1235 ZN=n1549 A2=n1349
XU1804 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n465 ZN=n1349 A2=n684
XU1802 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2228 ZN=n1234 A1=n1377 A3=n1257
+ A4=n1404
XU1801 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1254 ZN=n1404 A2=n541
XU1800 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1377 A1=n1796 A3=n1256 A2=n1433
XU2179 OAI211D1BWP7T $PINS A2=n1910 ZN=n1912 A1=n516 B=n1909 VDD=VDD C=n1908
+ VSS=VSS
XU2177 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1903 ZN=n1921 A1=n1904 A3=n2703
+ A4=n1901
XU2176 NR4D0BWP7T $PINS VSS=VSS A4=n1897 VDD=VDD ZN=n1934 A3=n1898 A2=n1899
+ A1=n149
XU2175 IND4D1BWP7T $PINS VSS=VSS A1=n1896 VDD=VDD B1=n1895 B2=n2302 B3=n1103
+ ZN=n1897
XU2172 XNR4D2BWP7T $PINS A1=n2125 A2=n1677 ZN=rout<33> A3=rin<1> A4=n2776
+ VDD=VDD VSS=VSS
XU2170 XNR4D0BWP7T $PINS A1=n1585 A2=n2078 ZN=rout<97> A3=rin<65> A4=n1887
+ VDD=VDD VSS=VSS
XU2165 XNR4D0BWP7T $PINS A1=n1719 A2=n2107 ZN=rout<55> A3=rin<23> A4=n1940
+ VDD=VDD VSS=VSS
XU2160 XNR4D2BWP7T $PINS A1=n1606 A2=n2110 ZN=rout<54> A3=rin<22> A4=n1881
+ VDD=VDD VSS=VSS
XU2158 XNR4D2BWP7T $PINS A1=n1363 A2=n2123 ZN=rout<37> A3=rin<5> A4=n1879
+ VDD=VDD VSS=VSS
XU2157 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=sout1<28> A2=n1532 Z=n2123
XU2156 XNR4D2BWP7T $PINS A1=n2605 A2=n2116 ZN=rout<53> A3=rin<21> A4=n1879
+ VDD=VDD VSS=VSS
XU2155 XNR3D0BWP7T $PINS A1=n1877 A2=n1876 VDD=VDD VSS=VSS A3=n1677 ZN=n1879
XU2153 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2608 A2=n2106 Z=n2116
XU2152 XNR4D2BWP7T $PINS A1=n2617 A2=n2121 ZN=rout<38> A3=rin<6> A4=n1881
+ VDD=VDD VSS=VSS
XU2151 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1873 A2=n1872 ZN=n1881
XU2148 XNR4D0BWP7T $PINS A1=n1869 A2=n1868 ZN=n1870 A3=n1867 A4=rin<2> VDD=VDD
+ VSS=VSS
XU2147 AOI22D1BWP7T $PINS B1=n1348 A2=sout1<13> ZN=n1867 A1=sout1<15> VDD=VDD
+ B2=n1355 VSS=VSS
XU2146 XNR4D2BWP7T $PINS A1=n1876 A2=n1866 ZN=rout<35> A3=rin<3> A4=n1865
+ VDD=VDD VSS=VSS
XU2143 XNR4D2BWP7T $PINS A1=n2106 A2=n1862 ZN=rout<36> A3=n1861 A4=n1860
+ VDD=VDD VSS=VSS
XU2142 XNR4D0BWP7T $PINS A1=n2109 A2=n1868 ZN=n1860 A3=rin<4> A4=n1859 VDD=VDD
+ VSS=VSS
XU2136 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1849 A1=n1846 A3=n1844 A2=n1845
XU2135 NR4D0BWP7T $PINS VSS=VSS A4=n1840 VDD=VDD ZN=n1850 A3=n1841 A2=n1842
+ A1=n1843
XU2132 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2256 A1=n1833 ZN=n1834 A3=n1831
XU2128 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2303 ZN=n1820 A1=n1819 A3=n1817
+ A4=n1816
XU2124 IND4D1BWP7T $PINS VSS=VSS A1=n1804 VDD=VDD B1=n1803 B2=n1802 B3=n160
+ ZN=n1805
XU2123 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1799 A1=n1800 ZN=n1806 A3=n1798
XU2122 NR4D0BWP7T $PINS VSS=VSS A4=n1794 VDD=VDD ZN=n1800 A3=n1795 A2=n1796
+ A1=n1797
XU2121 XNR4D0BWP7T $PINS A1=n1938 A2=n1793 ZN=rout<42> A3=n1792 A4=n1791
+ VDD=VDD VSS=VSS
XU2120 MAOI22D1BWP7T $PINS A2=n2782 ZN=n1791 A1=n2128 B2=n2128 VDD=VDD B1=n2782
+ VSS=VSS
XU2119 MUX2ND0BWP7T $PINS ZN=n1792 I1=n2622 I0=n2337 S=rin<10> VDD=VDD VSS=VSS
XU2118 XNR4D2BWP7T $PINS A1=n2113 A2=n1876 ZN=rout<43> A3=n1789 A4=n1788
+ VDD=VDD VSS=VSS
XU2117 MUX2ND1BWP7T $PINS ZN=n1789 I1=n2489 I0=n2333 S=rin<11> VDD=VDD VSS=VSS
XU2114 XNR4D2BWP7T $PINS A1=n1938 A2=n1784 ZN=rout<44> A3=n1783 A4=n1782
+ VDD=VDD VSS=VSS
XU2113 XNR4D0BWP7T $PINS A1=n1856 A2=n2608 ZN=n1782 A3=n1872 A4=rin<12> VDD=VDD
+ VSS=VSS
XU2109 XNR4D0BWP7T $PINS A1=n1780 A2=rin<18> ZN=n1781 A3=n2721 A4=n1779 VDD=VDD
+ VSS=VSS
XU2105 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1769 A1=n1770 ZN=n1772 A3=n1768
XU2104 NR4D0BWP7T $PINS VSS=VSS A4=n1764 VDD=VDD ZN=n1768 A3=n1765 A2=n1766
+ A1=n1041
XU2103 NR4D0BWP7T $PINS VSS=VSS A4=n1760 VDD=VDD ZN=n1769 A3=n1761 A2=n1762
+ A1=n1763
XU2101 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1754 ZN=n1757 A1=n1755 A3=n1753
+ A4=n1752
XU2100 AOI21D1BWP7T $PINS VSS=VSS A2=n1750 VDD=VDD A1=n1751 B=n1749 ZN=n1753
XU2099 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1747 ZN=n1759 A1=n1748 A3=n2087
+ A4=n960
XU2095 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1733 ZN=n1744 A1=n1734 A3=n1732
+ A4=n1731
XU2093 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1725 A1=n1726 ZN=n1728 A3=n1724
XU2092 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1721 A2=n1722 A1=n807 ZN=n1725
+ C=n1720
XU2087 INVD0BWP7T $PINS ZN=n1713 VSS=VSS VDD=VDD I=n2115
XU2082 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1739 ZN=n1702 A1=n1701 A3=n1700
+ A4=n1699
XU2080 NR4D1BWP7T $PINS VSS=VSS A4=n1692 VDD=VDD ZN=n1709 A3=n1693 A2=n1694
+ A1=n1773
XU2079 AO211D0BWP7T $PINS Z=n1692 C=n1688 B=n1689 A2=n1690 VDD=VDD A1=n1691
+ VSS=VSS
XU2078 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1686 ZN=n1688 A1=n1687 A3=n2271
+ A4=n1684
XU2077 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1683 ZN=n1686 A2=n922
XU2076 OAI211D0BWP7T $PINS A2=n1680 ZN=n1689 A1=n1681 B=n163 VDD=VDD C=n1679
+ VSS=VSS
XU2073 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n960 ZN=n1672 A1=n1671 A3=n1670
+ A4=n1724
XU2070 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1755 A1=n1664 ZN=n1665 A2=n1663
XU2069 NR4D1BWP7T $PINS VSS=VSS A4=n1661 VDD=VDD ZN=n1669 A3=n922 A2=n1662
+ A1=n1763
XU2068 INVD0BWP7T $PINS ZN=n1866 VSS=VSS VDD=VDD I=n1660
XU2067 XNR4D0BWP7T $PINS A1=n1418 A2=n1659 ZN=n1660 A3=n1861 A4=n1617 VDD=VDD
+ VSS=VSS
XU2065 XNR4D2BWP7T $PINS A1=n1532 A2=n1793 ZN=rout<52> A3=n1780 A4=n1658
+ VDD=VDD VSS=VSS
XU2064 XNR4D0BWP7T $PINS A1=n2108 A2=n1659 ZN=n1658 A3=rin<20> A4=n1657 VDD=VDD
+ VSS=VSS
XU2048 AN4D1BWP7T $PINS VSS=VSS A1=n1687 VDD=VDD A2=n1650 A3=n1649 A4=n1648
+ Z=n1651
XU2046 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1734 ZN=n1646 A2=n1732
XU2043 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2255 ZN=n1639 A2=n1700
XU2042 NR4D0BWP7T $PINS VSS=VSS A4=n1666 VDD=VDD ZN=n1649 A3=n1635 A2=n1636
+ A1=n1637
XU2041 NR4D0BWP7T $PINS VSS=VSS A4=n1633 VDD=VDD ZN=n1652 A3=n1693 A2=n1634
+ A1=n1694
XU2040 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1631 ZN=n1633 A1=n2696 A3=n1630
+ A4=n1629
XU2037 NR4D0BWP7T $PINS VSS=VSS A4=n1619 VDD=VDD ZN=n1624 A3=n1620 A2=n1621
+ A1=n1622
XU2035 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1614 ZN=n1754 A2=n1613
XU2034 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1612 ZN=n1613 A1=n1631 A3=n1611
+ A4=n1610
XU2031 NR4D0BWP7T $PINS VSS=VSS A4=n1601 VDD=VDD ZN=n1604 A3=n1602 A2=n1050
+ A1=n1622
XU2028 XNR4D0BWP7T $PINS A1=n2128 A2=n1862 ZN=rout<58> A3=n1594 A4=n1593
+ VDD=VDD VSS=VSS
XU2024 MUX2ND0BWP7T $PINS ZN=n1594 I1=n2472 I0=n2348 S=rin<26> VDD=VDD VSS=VSS
XU2019 XNR4D0BWP7T $PINS A1=n1877 A2=n1911 ZN=n1592 A3=rin<27> A4=n1788 VDD=VDD
+ VSS=VSS
XU2018 XNR3D0BWP7T $PINS A1=n1784 A2=n1581 VDD=VDD VSS=VSS A3=n2618 ZN=n1788
XU2008 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2258 ZN=n1565 A2=n1558
XU2007 AOI21D0BWP7T $PINS VSS=VSS A2=n1556 VDD=VDD A1=n1557 B=n1836 ZN=n1590
XU2005 NR4D0BWP7T $PINS VSS=VSS A4=n1804 VDD=VDD ZN=n1557 A3=n1549 A2=n1550
+ A1=n1551
XU2004 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1548 ZN=n1804 A2=n1560
XU2000 NR4D0BWP7T $PINS VSS=VSS A4=n1534 VDD=VDD ZN=n1539 A3=n1535 A2=n1536
+ A1=n1537
XU1999 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1843 ZN=n1540 A2=n1533
XU1995 OAI211D1BWP7T $PINS A2=n1523 ZN=n1525 A1=n1524 B=n1770 VDD=VDD C=n1522
+ VSS=VSS
XU1994 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1521 A2=n1661 A1=n1664 ZN=n1522
+ C=n1520
XU1993 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2305 ZN=n1521 A2=n960
XU1992 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1618 ZN=n1661 A2=n1663
XU1990 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1700 ZN=n1517 A1=n1516 A3=n1515
+ A4=n1731
XU1987 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1507 ZN=n1509 A1=n1508 A3=n1747
+ A4=n1506
XU1984 AN4D1BWP7T $PINS VSS=VSS A1=n1500 VDD=VDD A2=n1499 A3=n1670 A4=n1737
+ Z=n1501
XU1983 NR4D1BWP7T $PINS VSS=VSS A4=n1498 VDD=VDD ZN=n1499 A3=n922 A2=n1683
+ A1=n1041
XU1981 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n680 ZN=n1495 A2=n910
XU1977 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1656 A2=n1869 Z=n2115
XU1975 OAI211D0BWP7T $PINS A2=n1808 ZN=n1488 A1=n1487 B=n1486 VDD=VDD C=n1485
+ VSS=VSS
XU1973 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1481 ZN=n1483 A1=n1572 A3=n2257
+ A4=n1548
XU1972 NR4D1BWP7T $PINS VSS=VSS A4=n1533 VDD=VDD ZN=n1481 A3=n1478 A2=n1843
+ A1=n1479
XU1971 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1477 A1=n160 ZN=n1583 A3=n1476
XU822 INVD0BWP7T $PINS ZN=n2288 VSS=VSS VDD=VDD I=n1626
XU724 INVD0BWP7T $PINS ZN=n2281 VSS=VSS VDD=VDD I=n1907
XU680 INVD1BWP7T $PINS ZN=n2278 VSS=VSS VDD=VDD I=n362
XU674 INVD0BWP7T $PINS ZN=n2276 VSS=VSS VDD=VDD I=n988
XU659 INVD0BWP7T $PINS ZN=n2275 VSS=VSS VDD=VDD I=n496
XU636 INVD1BWP7T $PINS ZN=n2271 VSS=VSS VDD=VDD I=n1647
XU635 INVD1BWP7T $PINS ZN=n2270 VSS=VSS VDD=VDD I=n1498
XU621 INVD0BWP7T $PINS ZN=n2269 VSS=VSS VDD=VDD I=n1749
XU517 INVD0BWP7T $PINS ZN=n2266 VSS=VSS VDD=VDD I=n119
XU504 INVD0BWP7T $PINS ZN=n2265 VSS=VSS VDD=VDD I=n141
XU468 INVD0BWP7T $PINS ZN=n2258 VSS=VSS VDD=VDD I=n1445
XU467 INVD0BWP7T $PINS ZN=n2257 VSS=VSS VDD=VDD I=n1567
XU421 INVD0BWP7T $PINS ZN=n2252 VSS=VSS VDD=VDD I=n2093
XU416 INVD0BWP7T $PINS ZN=n2251 VSS=VSS VDD=VDD I=n1065
XU401 INVD0BWP7T $PINS ZN=n2249 VSS=VSS VDD=VDD I=n530
XU369 INVD0BWP7T $PINS ZN=n2241 VSS=VSS VDD=VDD I=n1433
XU367 INVD0BWP7T $PINS ZN=n2240 VSS=VSS VDD=VDD I=n1392
XU341 INVD1BWP7T $PINS ZN=n2237 VSS=VSS VDD=VDD I=n1163
XU316 INVD0BWP7T $PINS ZN=n2235 VSS=VSS VDD=VDD I=n30
XU249 INVD0BWP7T $PINS ZN=n2228 VSS=VSS VDD=VDD I=n1478
XU169 INVD0BWP7T $PINS ZN=n2222 VSS=VSS VDD=VDD I=n1428
XU101 INVD0BWP7T $PINS ZN=n2214 VSS=VSS VDD=VDD I=n1254
XU50 INVD1BWP7T $PINS ZN=n2210 VSS=VSS VDD=VDD I=n1756
XU46 INVD0BWP7T $PINS ZN=n2209 VSS=VSS VDD=VDD I=n73
XU40 INVD0BWP7T $PINS ZN=n2206 VSS=VSS VDD=VDD I=n133
XU25 INVD0BWP7T $PINS ZN=n2200 VSS=VSS VDD=VDD I=n99
XU11 INVD0BWP7T $PINS ZN=n2196 VSS=VSS VDD=VDD I=n1955
XU1 INVD0BWP7T $PINS ZN=n2193 VSS=VSS VDD=VDD I=n1076
XU2280 XNR4D0BWP7T $PINS A1=n2128 A2=n1418 ZN=rout<40> A3=n2127 A4=rin<8>
+ VDD=VDD VSS=VSS
XU2279 XNR4D0BWP7T $PINS A1=n2126 A2=n1333 ZN=rout<41> A3=n2125 A4=rin<9>
+ VDD=VDD VSS=VSS
XU2278 XNR4D2BWP7T $PINS A1=n2124 A2=n2123 ZN=rout<45> A3=rin<13> A4=sout1<13>
+ VDD=VDD VSS=VSS
XU2277 XNR4D2BWP7T $PINS A1=n2122 A2=n2121 ZN=rout<46> A3=rin<14> A4=n2412
+ VDD=VDD VSS=VSS
XU2276 XNR4D0BWP7T $PINS A1=sout1<15> A2=n2120 ZN=rout<47> A3=n2119 A4=rin<15>
+ VDD=VDD VSS=VSS
XU2275 XNR4D2BWP7T $PINS A1=n2128 A2=n1617 ZN=rout<56> A3=n2118 A4=rin<24>
+ VDD=VDD VSS=VSS
XU2274 XNR4D2BWP7T $PINS A1=n2126 A2=n2454 ZN=rout<57> A3=rin<25> A4=n2117
+ VDD=VDD VSS=VSS
XU2272 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2115 A2=n2114 Z=n2124
XU2271 AOI22D0BWP7T $PINS B1=n1818 A2=n2113 ZN=n2114 A1=n2126 VDD=VDD B2=n2111
+ VSS=VSS
XU2270 XNR4D2BWP7T $PINS A1=n2122 A2=n1317 ZN=rout<62> A3=rin<30> A4=n2110
+ VDD=VDD VSS=VSS
XU2269 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2109 A2=n2108 Z=n2122
XU2268 XNR4D1BWP7T $PINS A1=n1493 A2=n2120 ZN=rout<63> A3=rin<31> A4=n2107
+ VDD=VDD VSS=VSS
XU2266 XNR4D2BWP7T $PINS A1=n2361 A2=n2103 ZN=rout<117> A3=rin<85> A4=n2102
+ VDD=VDD VSS=VSS
XU2265 XNR4D2BWP7T $PINS A1=n1603 A2=n2101 ZN=rout<120> A3=n2100 A4=rin<88>
+ VDD=VDD VSS=VSS
XU2264 XNR4D2BWP7T $PINS A1=sout0<7> A2=n2099 ZN=rout<121> A3=rin<89> A4=n2098
+ VDD=VDD VSS=VSS
XU2262 XNR4D0BWP7T $PINS A1=n2102 A2=rin<94> ZN=rout<126> A3=n1685 A4=n2095
+ VDD=VDD VSS=VSS
XU2260 XNR4D2BWP7T $PINS A1=sout0<5> A2=rin<95> ZN=rout<127> A3=n2092 A4=n2091
+ VDD=VDD VSS=VSS
XU2258 XNR4D2BWP7T $PINS A1=n1786 A2=n2099 ZN=rout<112> A3=rin<80> A4=n2092
+ VDD=VDD VSS=VSS
XU2255 XNR4D2BWP7T $PINS A1=n2084 A2=n1434 ZN=rout<105> A3=n2083 A4=n2082
+ VDD=VDD VSS=VSS
XU2254 MUX2ND0BWP7T $PINS ZN=n2083 I1=n1426 I0=n2081 S=rin<73> VDD=VDD VSS=VSS
XU2251 XNR4D2BWP7T $PINS A1=n2079 A2=n2078 ZN=rout<104> A3=rin<72> A4=n1742
+ VDD=VDD VSS=VSS
XU2250 XNR4D1BWP7T $PINS A1=n2076 A2=n2075 ZN=rout<118> A3=rin<86> A4=n1826
+ VDD=VDD VSS=VSS
XU2249 XNR4D1BWP7T $PINS A1=n1603 A2=n2075 ZN=rout<111> A3=rin<79> A4=n2074
+ VDD=VDD VSS=VSS
XU2245 XNR4D2BWP7T $PINS A1=n1790 A2=n2100 ZN=rout<119> A3=rin<87> A4=n2095
+ VDD=VDD VSS=VSS
XU2242 XNR4D2BWP7T $PINS A1=n28 A2=n2101 ZN=rout<113> A3=rin<81> A4=n2065
+ VDD=VDD VSS=VSS
XU2239 XNR4D2BWP7T $PINS A1=n2723 A2=rin<78> ZN=rout<110> A3=n2059 A4=n2058
+ VDD=VDD VSS=VSS
XU2237 MUX2ND0BWP7T $PINS ZN=n2057 I1=n1742 I0=sout0<7> S=rin<71> VDD=VDD
+ VSS=VSS
XU2231 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n2038 A2=n2207 A1=n814 ZN=n2041
+ C=n2037
XU2230 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2159 ZN=n2048 A1=n2036 A3=n2034
+ A4=n2033
XU2227 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2024 B1=n2023 B2=n2320 B3=n2021
+ ZN=n2027
XU2226 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1 ZN=n2028 A2=n2019
XU2224 IND4D1BWP7T $PINS VSS=VSS A1=n2014 VDD=VDD B1=n2013 B2=n2012 B3=n2011
+ ZN=n2015
XU2223 IND4D0BWP7T $PINS VSS=VSS A1=n2032 VDD=VDD B1=n2010 B2=n2009 B3=n2008
+ ZN=n2054
XU2221 IND4D0BWP7T $PINS VSS=VSS A1=n2004 VDD=VDD B1=n2003 B2=n2042 B3=n2294
+ ZN=n2056
XU2220 XNR4D2BWP7T $PINS A1=n2618 A2=n2127 ZN=rout<32> A3=rin<0> A4=n2000
+ VDD=VDD VSS=VSS
XU2218 XNR4D2BWP7T $PINS A1=n1581 A2=n2118 ZN=rout<48> A3=rin<16> A4=n2000
+ VDD=VDD VSS=VSS
XU2215 XNR4D0BWP7T $PINS A1=n1682 A2=n2103 ZN=rout<125> A3=rin<93> A4=n1990
+ VDD=VDD VSS=VSS
XU2214 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1989 A2=n1988 ZN=n2103
XU2213 XNR4D2BWP7T $PINS A1=n1603 A2=rin<70> ZN=rout<102> A3=n1987 A4=n1990
+ VDD=VDD VSS=VSS
XU2210 AOI31D0BWP7T $PINS B=n1978 ZN=n1982 A1=n1981 A2=n1980 VDD=VDD A3=n1979
+ VSS=VSS
XU2209 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1977 ZN=n1979 A2=n1976
XU2205 AOI21D0BWP7T $PINS VSS=VSS A2=n1962 VDD=VDD A1=n1963 B=n1961 ZN=n1984
XU2201 AOI31D0BWP7T $PINS B=n1947 ZN=n1985 A1=n1949 A2=n1980 VDD=VDD A3=n1948
+ VSS=VSS
XU2200 NR4D0BWP7T $PINS VSS=VSS A4=n2334 VDD=VDD ZN=n1948 A3=n1944 A2=n1945
+ A1=n1946
XU2196 XNR4D2BWP7T $PINS A1=rin<69> A2=n1826 ZN=rout<101> A3=n1941 A4=n2058
+ VDD=VDD VSS=VSS
XU2192 XNR4D2BWP7T $PINS A1=n1656 A2=n2119 ZN=rout<39> A3=rin<7> A4=n1940
+ VDD=VDD VSS=VSS
XU2190 XOR4D2BWP7T $PINS A3=n1677 VDD=VDD A4=rin<17> VSS=VSS A1=n1938 A2=n2117
+ Z=rout<49>
XU2188 XNR4D2BWP7T $PINS A1=n2723 A2=n2076 ZN=rout<109> A3=rin<77> A4=n1941
+ VDD=VDD VSS=VSS
XU2187 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1936 A2=n1935 ZN=n1941
XU2185 OAI211D0BWP7T $PINS A2=n1933 ZN=n2089 A1=n1934 B=n1932 VDD=VDD C=n1931
+ VSS=VSS
XU2184 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1928 A1=n1930 ZN=n1931 A2=n1929
XU2183 IND4D0BWP7T $PINS VSS=VSS A1=n1927 VDD=VDD B1=n1926 B2=n1925 B3=n1924
+ ZN=n1929
XU2180 NR4D0BWP7T $PINS VSS=VSS A4=n1912 VDD=VDD ZN=n1917 A3=n1913 A2=n1053
+ A1=n1915
XU679 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n621 ZN=n705 A2=n794
XU1636 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1698 ZN=n1749 A2=n2237
XU446 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1139 ZN=n2255
XU1917 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1798 ZN=n1367 A1=n1455 A3=n1366
+ A4=n1365
XU1339 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2227 ZN=n1236 A2=n476
XU1371 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1374 ZN=n1251 A2=n1071
XU1327 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1362 ZN=n1429 A2=n1071
XU1481 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1087 ZN=n1690 A2=n1664
XU1290 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n402 ZN=n1246 A2=n1580
XU1773 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1216 ZN=n1428 A2=n1563
XU376 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n533 ZN=n370 A2=n2207
XU648 CKXOR2D2BWP7T $PINS A1=rin<121> VDD=VDD VSS=VSS A2=rk0<25> Z=n961
XU358 CKXOR2D2BWP7T $PINS A1=rin<113> VDD=VDD VSS=VSS A2=rk0<17> Z=n124
XU1667 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1117 ZN=n1756 A2=n1116
XU353 CKXOR2D2BWP7T $PINS A1=rin<115> VDD=VDD VSS=VSS A2=rk0<19> Z=n555
XU95 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<108> A2=rk0<12> ZN=n3
XU78 XOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<26> A2=rin<58> Z=sin1<26>
XU1471 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<51> A2=rk1<19> ZN=n1304
XU1474 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<52> A2=n2104 ZN=n1315
XU1282 CKXOR2D2BWP7T $PINS A1=rin<34> VDD=VDD VSS=VSS A2=n385 Z=n1347
XU83 CKXOR2D2BWP7T $PINS A1=rk1<13> VDD=VDD VSS=VSS A2=rin<45> Z=sin1<13>
XU359 CKXOR2D2BWP7T $PINS A1=rin<114> VDD=VDD VSS=VSS A2=rk0<18> Z=n99
XU1281 CKXOR2D1BWP7T $PINS A1=rin<37> VDD=VDD VSS=VSS A2=rk1<5> Z=n1048
XU1283 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<33> A2=n2164 ZN=n1037
XU86 CKXOR2D2BWP7T $PINS A1=rk1<10> VDD=VDD VSS=VSS A2=rin<42> Z=sin1<10>
XU1829 INVD0BWP7T $PINS ZN=n2361 VSS=VSS VDD=VDD I=n2601
XU1764 INVD0BWP7T $PINS ZN=n2357 VSS=VSS VDD=VDD I=n2727
XU1740 INVD0BWP7T $PINS ZN=n2356 VSS=VSS VDD=VDD I=n2454
XU1733 INVD0BWP7T $PINS ZN=n2355 VSS=VSS VDD=VDD I=n2608
XU1716 INVD0BWP7T $PINS ZN=n2353 VSS=VSS VDD=VDD I=n2691
XU1652 INVD0BWP7T $PINS ZN=n2348 VSS=VSS VDD=VDD I=n2472
XU1603 INVD0BWP7T $PINS ZN=n2345 VSS=VSS VDD=VDD I=n946
XU1523 INVD0BWP7T $PINS ZN=n2337 VSS=VSS VDD=VDD I=n2622
XU1500 INVD0BWP7T $PINS ZN=n2336 VSS=VSS VDD=VDD I=n2412
XU1491 INVD0BWP7T $PINS ZN=n2334 VSS=VSS VDD=VDD I=n466
XU1488 INVD0BWP7T $PINS ZN=n2333 VSS=VSS VDD=VDD I=n2489
XU1482 INVD0BWP7T $PINS ZN=n2332 VSS=VSS VDD=VDD I=n1965
XU1452 INVD0BWP7T $PINS ZN=n2328 VSS=VSS VDD=VDD I=n875
XU1437 INVD0BWP7T $PINS ZN=n2327 VSS=VSS VDD=VDD I=n1207
XU1420 INVD1BWP7T $PINS ZN=n2325 VSS=VSS VDD=VDD I=n594
XU1348 INVD0BWP7T $PINS ZN=n2322 VSS=VSS VDD=VDD I=n929
XU1346 INVD0BWP7T $PINS ZN=n2321 VSS=VSS VDD=VDD I=n163
XU1335 INVD0BWP7T $PINS ZN=n2319 VSS=VSS VDD=VDD I=n1286
XU1301 INVD0BWP7T $PINS ZN=n2314 VSS=VSS VDD=VDD I=n1928
XU1291 INVD0BWP7T $PINS ZN=n2313 VSS=VSS VDD=VDD I=n593
XU1287 INVD0BWP7T $PINS ZN=n2311 VSS=VSS VDD=VDD I=n694
XU1108 INVD0BWP7T $PINS ZN=n2307 VSS=VSS VDD=VDD I=n728
XU1055 INVD0BWP7T $PINS ZN=n2306 VSS=VSS VDD=VDD I=n1762
XU1010 INVD0BWP7T $PINS ZN=n2303 VSS=VSS VDD=VDD I=n1346
XU996 INVD0BWP7T $PINS ZN=n2302 VSS=VSS VDD=VDD I=n675
XU965 INVD0BWP7T $PINS ZN=n2300 VSS=VSS VDD=VDD I=n279
XU916 INVD1BWP7T $PINS ZN=n2294 VSS=VSS VDD=VDD I=n2037
XU897 INVD0BWP7T $PINS ZN=n2293 VSS=VSS VDD=VDD I=n2019
XU1745 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2270 ZN=n1183 A1=n1319 A3=n1699
+ A4=n1306
XU121 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1915 ZN=n863 A2=n69
XU1810 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1410 A1=n1369 ZN=n1451 A3=n1238
XU106 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n313 A2=n2161
XU1525 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1698 ZN=n1764 A2=n1663
XU327 INVD0BWP7T $PINS ZN=n2236 VSS=VSS VDD=VDD I=n1141
XU660 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n470 ZN=n794 A2=n620
XU379 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n228 ZN=n2244
XU204 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1241 ZN=n2226
XU222 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1246 ZN=n2227
XU145 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n7 ZN=n417 A2=n6
XU1486 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1618 ZN=n1303 A2=n1690
XU138 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n124 ZN=n2218
XU131 INVD1BWP7T $PINS ZN=n2217 VSS=VSS VDD=VDD I=n961
XU122 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n650 ZN=n1910 A2=n6
XU31 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1315 ZN=n2203
XU32 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1304 ZN=n2204
XU639 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<120> A2=rk0<24> ZN=n621
XU1414 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2193 ZN=n1482 A2=n1075
XU355 CKXOR2D4BWP7T $PINS A1=rin<117> VDD=VDD VSS=VSS A2=rk0<21> Z=n533
XU75 XOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<29> A2=rin<61> Z=sin1<29>
XU77 CKXOR2D2BWP7T $PINS A1=rk1<27> VDD=VDD VSS=VSS A2=rin<59> Z=sin1<27>
XU94 CKXOR2D2BWP7T $PINS A1=rin<107> VDD=VDD VSS=VSS A2=rk0<11> Z=n72
XU644 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<123> A2=n393 ZN=n745
XU651 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<122> A2=n134 ZN=n1955
XU2291 OAI211D2BWP7T $PINS A2=n1005 ZN=n2406 A1=n183 B=n2147 VDD=VDD C=n1271
+ VSS=VSS
XU2288 OAI211D2BWP7T $PINS A2=n1015 ZN=n2403 A1=n2131 B=n2144 VDD=VDD C=n1847
+ VSS=VSS
XU1230 AOI22D1BWP7T $PINS B1=n1745 A2=n1031 ZN=n1024 A1=n2772 VDD=VDD B2=n920
+ VSS=VSS
XU1222 IAO22D1BWP7T $PINS VSS=VSS VDD=VDD B2=n1742 B1=n1494 ZN=n1988 A1=n1742
+ A2=n1494
XU1897 AOI21D1BWP7T $PINS A2=n1345 A1=n1727 ZN=n1939 VDD=VDD B=n1344 VSS=VSS
XU220 NR4D1BWP7T $PINS VSS=VSS A4=n16 VDD=VDD ZN=n44 A3=n17 A2=n430 A1=n322
XU844 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n742 ZN=n271 A3=n269 A2=n270
+ A1=n2325
XU1770 AOI21D0BWP7T $PINS VSS=VSS A2=n1211 VDD=VDD A1=n2696 B=n2210 ZN=n1212
XU247 NR4D1BWP7T $PINS VSS=VSS A4=n277 VDD=VDD ZN=n20 A3=n444 A2=n191 A1=n184
XU1924 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1380 B1=n1379 B2=n1451 B3=n1378
+ ZN=n1381
XU2208 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1974 ZN=n1976 A1=n1975 A3=n1973
+ A4=n1972
XU1753 AOI31D1BWP7T $PINS B=n1708 ZN=n1214 A1=n95 A2=n2741 VDD=VDD A3=n1194
+ VSS=VSS
XU244 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n667 A1=n416 ZN=n444 A3=n855
XU1014 IND4D1BWP7T $PINS VSS=VSS A1=n762 VDD=VDD B1=n479 B2=n949 ZN=n712
+ B3=n939
XU1851 AOI31D0BWP7T $PINS B=n459 ZN=n1301 A1=n1448 A2=n1572 VDD=VDD A3=n1285
+ VSS=VSS
XU1205 NR4D1BWP7T $PINS VSS=VSS A4=n856 VDD=VDD ZN=n860 A3=n857 A2=n858
+ A1=n1061
XU1534 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1088 ZN=n1123 A1=n1829 A3=n1184
+ A4=n2087
XU1738 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1174 A2=n1691 A1=n1618 ZN=n1175
+ C=n1173
XU1854 INR4D1BWP7T $PINS ZN=n1419 A1=n1409 B3=n2319 B2=n1475 VDD=VDD B1=n1551
+ VSS=VSS
XU1151 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n967 A1=n727 A2=n954 A4=n725 A3=n726
XU823 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n718 ZN=n1954 A2=n257
XU2071 NR4D1BWP7T $PINS VSS=VSS A4=n1665 VDD=VDD ZN=n1668 A3=n1666 A2=n1667
+ A1=n1765
XU1702 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1177 ZN=n1145 A1=n1144 A3=n2273
+ A4=n1322
XU1408 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n778 ZN=n2324
XU198 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1182 ZN=n286 A2=n743
XU1967 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1464 ZN=n1466 A1=n1838 A3=n1470
+ A4=n1463
XU605 IND4D1BWP7T $PINS VSS=VSS A1=n306 VDD=VDD B1=n667 B2=n280 B3=n672 ZN=n190
XU1382 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1222 B1=n2628 B2=n1441 B3=n1282
+ ZN=n1044
XU1022 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n496 ZN=n2036 A2=n914
XU760 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n795 ZN=n718 A2=n1137
XU547 AO211D2BWP7T $PINS VSS=VSS A1=n664 VDD=VDD A2=n996 B=n1004 C=n338 Z=n1012
XU1658 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1192 ZN=n1679 A2=n1511
XU191 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n886 ZN=n901 A2=n278
XU1231 AOI21D1BWP7T $PINS VSS=VSS A2=n1047 VDD=VDD A1=n925 B=n1083 ZN=n926
XU1961 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1447 ZN=n1449 A1=n1448 A3=n1538
+ A4=n1561
XU1836 NR3D1BWP7T $PINS A3=n1268 VSS=VSS VDD=VDD A1=n1432 A2=n1550 ZN=n1546
XU685 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n470 ZN=n245 A2=n604
XU123 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1046 ZN=n675 A2=n1910
XU646 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n224 ZN=n737 A2=n470
XU1817 AOI31D1BWP7T $PINS B=n1544 ZN=n1247 A1=n1246 A2=n1245 VDD=VDD A3=n427
+ VSS=VSS
XU1621 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2805 ZN=n1647 A2=n2238
XU242 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2161 ZN=n648 A2=n567
XU457 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n153 ZN=n995 A2=n357
XU437 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1201 ZN=n2253
XU551 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2044 ZN=n824 A2=n554
XU178 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2161 ZN=n882 A2=n743
XU436 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n355 ZN=n988 A2=n103
XU2513 OAI211D0BWP7T $PINS A2=n1933 ZN=n2633 A1=n2495 B=n1886 VDD=VDD C=n2130
+ VSS=VSS
XU2508 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n1380 ZN=n2628 A1=n1279 B2=n2163
XU2507 OAI211D1BWP7T $PINS A2=n1126 ZN=n2627 A1=n1680 B=n2273 VDD=VDD C=n1154
+ VSS=VSS
XU2506 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n783 ZN=n2626 A1=n1945 B2=n471
XU2505 OAI211D0BWP7T $PINS A2=n342 ZN=n2625 A1=n340 B=n339 VDD=VDD C=n524
+ VSS=VSS
XU2504 OAI211D0BWP7T $PINS A2=n57 ZN=n2624 A1=n644 B=n863 VDD=VDD C=n2526
+ VSS=VSS
XU2498 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2132 Z=n2618
XU2488 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<12> Z=n2608
XU2452 INVD0BWP7T $PINS ZN=n2572 VSS=VSS VDD=VDD I=rk0<0>
XU2451 INVD0BWP7T $PINS ZN=n2571 VSS=VSS VDD=VDD I=n2572
XU2443 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD I=rk0<7> Z=n2563
XU2440 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<125> A2=rk0<29> ZN=n2560
XU2428 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n2259 ZN=n2548 A1=n1395 B2=n1538
XU2427 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n317 Z=n2547
XU2420 IND3D0BWP7T $PINS VSS=VSS VDD=VDD B1=n1380 ZN=n2540 A1=n1279 B2=n2163
XU2369 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<11> Z=n2489
XU1054 INVD1BWP7T $PINS ZN=n2305 VSS=VSS VDD=VDD I=n1636
XU57 INVD0BWP7T $PINS ZN=n2211 VSS=VSS VDD=VDD I=n1664
XU476 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n554 ZN=n161 A2=n782
XU241 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n1046 ZN=n191 A2=n80
XU1634 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1303 ZN=n1614 A2=n1616
XU328 INR2XD1BWP7T $PINS VSS=VSS VDD=VDD B1=n648 ZN=n677 A1=n70
XU1208 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1098 ZN=n870 A1=n2281 A3=n895
+ A4=n867
XU1146 NR4D0BWP7T $PINS VSS=VSS A4=n1965 VDD=VDD ZN=n715 A3=n712 A2=n713
+ A1=n726
XU1524 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1086 ZN=n1204 A2=n2805
XU1647 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n747 ZN=n1699 A2=n910
XU1289 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n439 ZN=n1580 A2=n1037
XU2202 NR4D1BWP7T $PINS VSS=VSS A4=n1966 VDD=VDD ZN=n1963 A3=n1950 A2=n1951
+ A1=n1952
XU2029 IND4D0BWP7T $PINS VSS=VSS A1=n1597 VDD=VDD B1=n2271 B2=n1596 B3=n1595
+ ZN=n1598
XU2096 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1737 B1=n1736 B2=n1735 B3=n1760
+ ZN=n1738
XU1861 AOI31D0BWP7T $PINS B=n1824 ZN=n1300 A1=n1419 A2=n1293 VDD=VDD A3=n1292
+ VSS=VSS
XU1739 AOI31D0BWP7T $PINS B=n1623 ZN=n1215 A1=n1176 A2=n1311 VDD=VDD A3=n1175
+ VSS=VSS
XU2072 IND4D0BWP7T $PINS VSS=VSS A1=n1729 VDD=VDD B1=n2022 B2=n1669 B3=n1668
+ ZN=n1712
XU182 NR4D0BWP7T $PINS VSS=VSS A4=n13 VDD=VDD ZN=n9 A3=n192 A2=n674 A1=n858
XU2083 NR4D1BWP7T $PINS VSS=VSS A4=n1702 VDD=VDD ZN=n1707 A3=n1703 A2=n1704
+ A1=n1705
XU1980 NR4D0BWP7T $PINS VSS=VSS A4=n1774 VDD=VDD ZN=n1496 A3=n1491 A2=n1673
+ A1=n1492
XU1713 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1176 A1=n1151 A3=n1150 A2=n1527
XU1752 NR4D1BWP7T $PINS VSS=VSS A4=n1191 VDD=VDD ZN=n1194 A3=n1200 A2=n1192
+ A1=n923
XU1872 NR4D2BWP7T $PINS VSS=VSS A4=n1307 VDD=VDD ZN=n1310 A3=n2162 A2=n2080
+ A1=n1309
XU818 OAI31D0BWP7T $PINS VSS=VSS VDD=VDD B=n471 ZN=n253 A3=n250 A2=n2217
+ A1=n2196
XU1776 NR4D1BWP7T $PINS VSS=VSS A4=n1416 VDD=VDD ZN=n1221 A3=n1428 A2=n1223
+ A1=n1364
XU1627 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2272 ZN=n1761 A2=n2236
XU737 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2245 ZN=n749 A2=n250
XU144 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n674 A2=n61
XU649 CKND0BWP7T $PINS VDD=VDD VSS=VSS I=n1764 ZN=n2273
XU166 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n29 ZN=n649 A2=n743
XU1602 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1141 ZN=n1737 A2=n910
XU1427 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1231 ZN=n1535 A2=n1071
XU1357 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1438 ZN=n1279 A2=n485
XU112 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n73 ZN=n650 A2=n3
XU1478 CKXOR2D2BWP7T $PINS A1=rin<50> VDD=VDD VSS=VSS A2=rk1<18> Z=n1618
XU1297 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n421 ZN=n1055 A2=n1038
XU2267 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD B2=n2106 B1=n1532 ZN=n2120 A1=n2106
+ A2=n1532
XU633 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n219 A1=n220 ZN=n221 A2=n1933
XU610 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1903 ZN=n223 A1=n901 A3=n194
+ A4=n1132
XU990 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2324 ZN=n451 A1=n695 A3=n771 A4=n618
XU203 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n303 ZN=n321 A2=n1905
XU1204 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n855 ZN=n856 A1=n1924 A3=n854
+ A4=n853
XU1912 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1359 B1=n1484 B2=n1840 B3=n1358
+ ZN=n1360
XU827 IND4D0BWP7T $PINS VSS=VSS A1=n796 VDD=VDD B1=n398 B2=n1973 ZN=n260
+ B3=n259
XU1066 NR4D0BWP7T $PINS VSS=VSS A4=n824 VDD=VDD ZN=n573 A3=n563 A2=n564 A1=n840
XU1601 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1601 A1=n1093 A2=n2255 A3=n1700
XU1338 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n498 ZN=n2320
XU1305 CKND0BWP7T $PINS ZN=n2315 VSS=VSS VDD=VDD I=n200
XU1734 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1611 ZN=n1174 A1=n1198 A3=n2269
+ A4=n1595
XU227 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n57 ZN=n305 A2=n33
XU1803 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1262 A1=n1239 A2=n1372 A4=n1234
+ A3=n1281
XU488 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1092 ZN=n109 A1=n975 A3=n154 A4=n346
XU597 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n2014 A2=n335 A1=n176 ZN=n178
+ C=n352
XU902 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n360 A1=n988 A2=n579 A4=n358 A3=n838
XU466 AOI21D1BWP7T $PINS VSS=VSS A1=n688 VDD=VDD B=n352 ZN=n498 A2=n814
XU678 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1091 ZN=n1967 A2=n2245
XU120 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n69 A2=n29
XU575 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n989 ZN=n529
XU410 OAI21D2BWP7T $PINS B=n505 A2=n342 ZN=n2004 VDD=VDD A1=n532 VSS=VSS
XU209 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n279 A2=n33
XU155 AOI21D2BWP7T $PINS A2=n567 A1=n1910 ZN=n317 VDD=VDD B=n61 VSS=VSS
XU681 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1083 ZN=n593 A2=n911
XU303 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n195 ZN=n640
XU202 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n61 ZN=n1905 A2=n743
XU111 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n426 ZN=n57 A2=n461
XU795 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n615 ZN=n728 A2=n2244
XU1590 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2272 ZN=n1636 A2=n1172
XU1860 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1292 A1=n1843 A2=n1794 A4=n1291
+ A3=n1396
XU2011 NR4D1BWP7T $PINS VSS=VSS A4=n1568 VDD=VDD ZN=n1571 A3=n1569 A2=n2224
+ A1=n1570
XU1376 INVD0BWP7T $PINS ZN=n1441 VSS=VSS VDD=VDD I=n1225
XU569 OAI21D2BWP7T $PINS B=n154 A2=n532 ZN=n374 VDD=VDD A1=n356 VSS=VSS
XU491 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n2037 ZN=n345 A2=n988
XU537 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n346 ZN=n501
XU1934 NR3D1BWP7T $PINS A3=n1391 VSS=VSS VDD=VDD A1=n1392 A2=n2088 ZN=n1547
XU1692 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1724 ZN=n1622
XU1674 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1138 ZN=n1674
XU2127 OAI31D1BWP7T $PINS B=n1812 A3=n581 ZN=n1821 A2=n427 VDD=VDD A1=n421
+ VSS=VSS
XU704 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n486 ZN=n615 A2=n710
XU1464 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1802 A1=n1537 A2=n1417 A4=n1566
+ A3=n1576
XU879 AOI21D2BWP7T $PINS A2=n334 A1=n335 ZN=n843 VDD=VDD B=n824 VSS=VSS
XU1580 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1663 ZN=n1151 A2=n2253
XU1431 NR3D1BWP7T $PINS A3=n1057 VSS=VSS VDD=VDD A1=n1533 A2=n1395 ZN=n1293
XU1397 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1403 ZN=n1298 A2=n1390
XU1423 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1833 A2=n1056 ZN=n1346 A1=n1803
+ A4=n2228
XU1708 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1180 ZN=n1505
XU703 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n470 ZN=n710 A2=n921
XU1629 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1698 ZN=n1498 A2=n2236
XU1548 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2236 ZN=n1736 A2=n2253
XU386 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n263 ZN=n2245
XU1445 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1070 A1=n1429 A2=n1432 A4=n1388
+ A3=n1822
XU1369 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1042 A1=n1479 A2=n1433 A4=n1432
+ A3=n1554
XU1485 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1681 ZN=n1139 A2=n1616
XU1671 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1663 ZN=n1197 A2=n1303
XU1779 INR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1812 B1=n1392 A1=n1366
XU412 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n566 ZN=n2014 A2=n357
XU692 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n961 ZN=n228 A2=n925
XU567 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n153 ZN=n496 A2=n554
XU394 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n124 ZN=n532 A2=n141
XU1495 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n868 A2=n1126 ZN=n1765
XU463 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n869 ZN=n992 A2=n355
XU370 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n512 A2=n2249 ZN=n334
XU393 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n99 ZN=n141 A2=n512
XU1807 AOI21D2BWP7T $PINS VSS=VSS A1=n517 VDD=VDD B=n1236 ZN=n1410 A2=n608
XU362 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n124 ZN=n357 A2=n97
XU709 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n227 ZN=n795 A2=n2561
XU400 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n176 ZN=n125 A2=n340
XU728 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2561 ZN=n242 A2=n475
XU1358 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1362 ZN=n1797 A2=n889
XU1360 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1562 ZN=n1459 A2=n1071
XU1791 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1558 ZN=n1827
XU1549 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1172 ZN=n1113
XU1436 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n581 ZN=n1417 A2=n1216
XU403 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n533 ZN=n566 A2=n96
XU1355 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n2226 A2=n1216 ZN=n1828
XU1499 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1304 ZN=n1107 A2=n1086
XU1385 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2227 ZN=n1567 A2=n1562
XU1921 AOI21D2BWP7T $PINS VSS=VSS A1=n1375 VDD=VDD B=n1374 ZN=n1379 A2=n1438
XU1490 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n1086 A2=n2204 ZN=n1691
XU408 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n979 A2=n623 ZN=n128
XU385 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n979 ZN=n153 A2=n526
XU1298 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1462 ZN=n1216 A2=n1055
XU1402 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n485 ZN=n1392 A2=n1071
XU1286 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1357 ZN=n1478 A2=n1563
XU1476 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n2204 ZN=n1663 A2=n1722
XU1480 CKXOR2D2BWP7T $PINS A1=rin<49> VDD=VDD VSS=VSS A2=rk1<17> Z=n1664
XU1347 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n402 A2=n2214 ZN=n1413
XU1313 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1290 ZN=n1362 A2=n427
XU1326 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1254 ZN=n1071 A2=n402
XU1337 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n421 A2=n1040 ZN=n1273
XU1473 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<48> A2=rk1<16> ZN=n1717
XU395 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n153 ZN=n2247
XU1463 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n1216 ZN=n1566 A2=n1071
XU151 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n73 ZN=n33 A2=n872
XU1336 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1362 ZN=n1445 A2=n2226
XU1275 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1824 ZN=n1490
XU357 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n110 ZN=n342 A2=n570
XU388 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n533 ZN=n2044 A2=n110
XU1607 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n441 ZN=n1771 A2=n1117
XU1643 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1708 ZN=n1741
XU2145 AOI22D1BWP7T $PINS ZN=n1865 A1=n1627 A2=n2113 B2=n1632 VDD=VDD B1=n1818
+ VSS=VSS
XU2241 AOI22D2BWP7T $PINS ZN=n2065 A1=n1814 A2=n1513 B2=n1815 VDD=VDD B1=n1514
+ VSS=VSS
XU2248 AOI22D2BWP7T $PINS ZN=n2074 A1=n1814 A2=n2357 B2=n1815 VDD=VDD B1=n2727
+ VSS=VSS
XU2186 MUX2ND1BWP7T $PINS ZN=n2076 I1=n1685 I0=n1682 S=n1787 VDD=VDD VSS=VSS
XU2263 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD B2=n2097 B1=n1609 ZN=n2098 A1=n2097
+ A2=n1609
XU1226 AOI22D1BWP7T $PINS ZN=n918 A1=n1638 A2=n1514 B2=n2785 VDD=VDD B1=n1513
+ VSS=VSS
XU2088 AOI22D1BWP7T $PINS ZN=n1714 A1=n2115 A2=n1856 B2=n1713 VDD=VDD B1=n1543
+ VSS=VSS
XU2169 AOI22D1BWP7T $PINS ZN=n1887 A1=n1813 A2=n2353 B2=n2781 VDD=VDD B1=n2691
+ VSS=VSS
XU283 AOI21D1BWP7T $PINS A2=n46 A1=n1922 ZN=n2086 VDD=VDD B=n45 VSS=VSS
XU2195 AOI22D2BWP7T $PINS VSS=VSS VDD=VDD B2=n2601 A2=n1468 ZN=n2058 A1=n2361
+ B1=sout0<5>
XU2108 AOI22D1BWP7T $PINS ZN=n1779 A1=n1493 A2=n1471 B2=n1480 VDD=VDD B1=n1914
+ VSS=VSS
XU2061 AOI22D1BWP7T $PINS ZN=n1659 A1=n1914 A2=n1317 B2=n1471 VDD=VDD B1=n1328
+ VSS=VSS
XU2055 AOI22D2BWP7T $PINS ZN=n1780 A1=sout1<13> A2=n1333 B2=n1348 VDD=VDD
+ B1=n1342 VSS=VSS
XU2022 AOI22D1BWP7T $PINS ZN=n1862 A1=sout1<15> A2=n1333 B2=n1355 VDD=VDD
+ B1=n1342 VSS=VSS
XU976 OAI31D1BWP7T $PINS B=n1922 A3=n424 ZN=n450 A2=n425 VDD=VDD A1=n1930
+ VSS=VSS
XU2066 AOI22D2BWP7T $PINS ZN=n1861 A1=sout1<13> A2=n2412 B2=n1348 VDD=VDD
+ B1=n2336 VSS=VSS
XU252 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n24 A1=n69 A2=n214 A4=n22 A3=n27
XU869 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n330 A1=n640 A2=n2547 A4=n316 A3=n432
XU2058 AOI22D1BWP7T $PINS ZN=n2108 A1=n1627 A2=n1656 B2=n1632 VDD=VDD B1=n2782
+ VSS=VSS
XU998 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n458 A1=n478 A2=n1967 A4=n457
+ A3=n2345
XU945 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n395 A1=n483 A2=n597 A4=n605 A3=n964
XU1988 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1529 A1=n1512 A2=n1511 A4=n1509
+ A3=n1510
XU2375 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n2495 A1=n1930 A2=n866 A4=n864
+ A3=n865
XU2098 OAI31D1BWP7T $PINS B=n1741 A3=n2675 ZN=n1777 A2=n1743 VDD=VDD A1=n1744
+ VSS=VSS
XU1015 NR4D1BWP7T $PINS VSS=VSS A4=n480 VDD=VDD ZN=n481 A3=n712 A2=n607
+ A1=n1966
XU1238 NR4D1BWP7T $PINS VSS=VSS A4=n940 VDD=VDD ZN=n944 A3=n941 A2=n942 A1=n943
XU1241 NR4D1BWP7T $PINS VSS=VSS A4=n951 VDD=VDD ZN=n955 A3=n952 A2=n953 A1=n954
XU1769 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1211 A1=n1041 A2=n1694 A4=n1720
+ A3=n1743
XU560 NR4D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n183 A1=n914 A2=n995 A4=n146 A3=n1012
XU927 INR4D2BWP7T $PINS ZN=n490 A1=n723 B3=n596 B2=n755 VDD=VDD B1=n953 VSS=VSS
XU809 IINR4D2BWP7T $PINS VSS=VSS B1=n464 VDD=VDD B2=n246 ZN=n613 A2=n1973
+ A1=n956
XU1197 OAI31D1BWP7T $PINS B=n2055 A3=n839 ZN=n848 A2=n988 VDD=VDD A1=n840
+ VSS=VSS
XU995 NR3D1BWP7T $PINS A3=n1977 VSS=VSS VDD=VDD A1=n728 A2=n927 ZN=n946
XU1833 AOI21D0BWP7T $PINS A2=n1264 A1=n1482 ZN=n1880 VDD=VDD B=n1263 VSS=VSS
XU1237 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1974 A2=n938 ZN=n940 A1=n939
+ A4=n937
XU630 NR4D1BWP7T $PINS VSS=VSS A4=n213 VDD=VDD ZN=n216 A3=n1905 A2=n288 A1=n214
XU889 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n562 A2=n345 ZN=n379 A1=n834 A4=n344
XU935 NR4D1BWP7T $PINS VSS=VSS A4=n388 VDD=VDD ZN=n391 A3=n389 A2=n606 A1=n390
XU861 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n904 A1=n649 A2=n304 A4=n302 A3=n303
XU580 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2012 ZN=n169 A1=n368 A3=n159 A4=n158
XU338 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1839 A2=n83 ZN=n1923 A1=n905 A4=n297
XU955 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n466 A1=n943 A2=n929 A4=n397 A3=n603
XU502 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n569 A1=n116 A2=n2293 A3=n131
XU1949 OAI31D0BWP7T $PINS B=n1482 A3=n1421 ZN=n1423 A2=n1422 VDD=VDD A1=n1796
+ VSS=VSS
XU590 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n167 ZN=n168 A1=n522 A3=n166 A4=n828
XU954 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n723 A2=n1973 ZN=n397 A1=n716 A4=n701
XU1018 OAI31D1BWP7T $PINS B=n484 A3=n2243 ZN=n487 A2=n745 VDD=VDD A1=n486
+ VSS=VSS
XU1191 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n825 A1=n838 A2=n824 A4=n822 A3=n823
XU832 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n624 A2=n262 ZN=n1965 A1=n959 A4=n720
XU817 IND4D1BWP7T $PINS VSS=VSS A1=n785 VDD=VDD B1=n249 B2=n382 ZN=n468 B3=n723
XU1991 NR3D1BWP7T $PINS A3=n1517 VSS=VSS VDD=VDD A1=n1600 A2=n2080 ZN=n1770
XU290 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n298 A2=n300 ZN=n1899 A1=n49 A4=n1148
XU264 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n33 ZN=n898 A2=n1182
XU201 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n303 A2=n1182
XU1719 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1157 A1=n1320 A2=n1156 A4=n1716
+ A3=n1155
XU2006 INR4D1BWP7T $PINS ZN=n1556 A1=n1555 B3=n1552 B2=n1553 VDD=VDD B1=n1554
+ VSS=VSS
XU1092 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n612 A1=n719 A2=n610 A4=n609 A3=n748
XU1159 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n751 A1=n791 A2=n749 A4=n952 A3=n748
XU2045 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1643 A2=n1644 ZN=n1730 A1=n1645
+ A4=n1642
XU732 INR4D1BWP7T $PINS ZN=n619 A1=n714 B3=n697 B2=n755 VDD=VDD B1=n708 VSS=VSS
XU1179 AOI21D2BWP7T $PINS VSS=VSS A1=n1119 VDD=VDD B=n791 ZN=n1974 A2=n935
XU481 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n115 A1=n914 A2=n992 A4=n108 A3=n2320
XU777 AO21D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2769 B=n455 Z=n603 A2=n1100
XU1938 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n1399 A2=n1547 ZN=n1427 A1=n1810
+ A4=n1398
XU1986 NR4D0BWP7T $PINS VSS=VSS A4=n1504 VDD=VDD ZN=n1506 A3=n1622 A2=n1505
+ A1=n1761
XU2129 INR4D2BWP7T $PINS ZN=n1825 A1=n1823 B3=n2002 B2=n998 VDD=VDD B1=n1822
+ VSS=VSS
XU1194 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n832 A1=n831 A2=n830 A4=n829
+ A3=n2018
XU2222 IND4D1BWP7T $PINS VSS=VSS A1=n2007 VDD=VDD B1=n2011 B2=n2006 ZN=n2032
+ B3=n2005
XU555 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n993 A2=n859 A1=n141 ZN=n142
+ C=n1003
XU489 AOI21D2BWP7T $PINS VSS=VSS A1=n110 VDD=VDD B=n109 ZN=n364 A2=n731
XU460 INR3D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1007 ZN=n833 B2=n121 B1=n162
XU519 NR3D2BWP7T $PINS A3=n120 VSS=VSS VDD=VDD A1=n121 A2=n502 ZN=n2024
XU826 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1137 ZN=n796 A2=n1047
XU126 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n886 A2=n2284
XU780 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n795 ZN=n929 A2=n1101
XU596 NR3D1BWP7T $PINS A3=n366 VSS=VSS VDD=VDD A1=n363 A2=n175 ZN=n2003
XU167 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1907 ZN=n79 A2=n649
XU1628 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1109 ZN=n1695 A2=n1761
XU2038 AOI31D0BWP7T $PINS B=n1623 A1=n1625 ZN=n1654 A2=n1754 VDD=VDD A3=n1624
+ VSS=VSS
XU2203 OAI211D1BWP7T $PINS VSS=VSS C=n1953 VDD=VDD A2=n1955 ZN=n1957 A1=n1101
+ B=n1954
XU174 ND3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1930 A1=n79 A2=n1904 A3=n897
XU1012 NR3D1BWP7T $PINS A3=n477 VSS=VSS VDD=VDD A1=n1951 A2=n713 ZN=n957
XU991 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n968 A1=n595 A3=n64 A2=n452
XU1019 NR3D1BWP7T $PINS A3=n487 VSS=VSS VDD=VDD A1=n735 A2=n1964 ZN=n488
XU765 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n489 A1=n478 A2=n729 A4=n234 A3=n609
XU2225 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2052 A1=n2018 A2=n2017 A4=n2015
+ A3=n2016
XU2297 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2412 I=sout1<14>
XU773 OAI211D1BWP7T $PINS VSS=VSS C=n1208 VDD=VDD A2=n794 ZN=n236 A1=n1047
+ B=n2311
XU1873 IND4D0BWP7T $PINS VSS=VSS A1=n1335 VDD=VDD B1=n1312 B2=n1311 ZN=n1345
+ B3=n1310
XU1989 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n2288 A2=n2255 ZN=n1526 A1=n2663
+ A4=n2269
XU2049 OAI22D0BWP7T $PINS ZN=n1653 A1=n1652 A2=n1675 B2=n2210 VDD=VDD B1=n1651
+ VSS=VSS
XU1195 AOI31D1BWP7T $PINS B=n2051 A1=n834 ZN=n851 A2=n833 VDD=VDD A3=n832
+ VSS=VSS
XU1260 AOI31D1BWP7T $PINS B=n1015 A1=n1018 ZN=n1019 A2=n1017 VDD=VDD A3=n1016
+ VSS=VSS
XU190 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n57 ZN=n278 A2=n1910
XU599 OAI31D1BWP7T $PINS B=n2045 A3=n179 ZN=n181 A2=n180 VDD=VDD A1=n994
+ VSS=VSS
XU2137 AOI31D1BWP7T $PINS B=n459 A1=n1850 ZN=n1851 A2=n1849 VDD=VDD A3=n1848
+ VSS=VSS
XU1654 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n2270 A2=n2306 ZN=n1207 A1=n1188
+ A4=n1684
XU1785 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n1221 A2=n1293 ZN=n1264 A1=n1222
+ A4=n1220
XU1831 OAI31D1BWP7T $PINS B=n1465 A3=n1259 ZN=n1260 A2=n1450 VDD=VDD A1=n1353
+ VSS=VSS
XU2044 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1644 A1=n1641 A2=n1640 A4=n1639
+ A3=n1760
XU581 AOI21D2BWP7T $PINS VSS=VSS A2=n814 VDD=VDD A1=n688 B=n369 ZN=n999
XU1706 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1736 ZN=n1631 A2=n1197
XU1911 OAI211D1BWP7T $PINS A2=n1357 ZN=n1358 A1=n1580 B=n1356 VDD=VDD C=n1560
+ VSS=VSS
XU2001 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1539 ZN=n1541 A1=n1540 A3=n1833
+ A4=n1538
XU1903 NR3D1BWP7T $PINS A3=n1350 VSS=VSS VDD=VDD A1=n1534 A2=n1395 ZN=n1359
XU1904 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1352 A1=n1537 A2=n1535 A4=n1460
+ A3=n1351
XU1696 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1615 ZN=n1760
XU1630 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1172 ZN=n1189 A2=n1303
XU1294 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2227 ZN=n1842 A2=n1231
XU2571 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n34 Z=n2691
XU2564 INVD0BWP7T $PINS ZN=n2684 VSS=VSS VDD=VDD I=n2698
XU2557 INVD0BWP7T $PINS ZN=n2677 VSS=VSS VDD=VDD I=n2678
XU2541 INVD0BWP7T $PINS ZN=n2661 VSS=VSS VDD=VDD I=n1712
XU2540 INVD0BWP7T $PINS ZN=n2660 VSS=VSS VDD=VDD I=n2661
XU2534 INVD0BWP7T $PINS ZN=n2654 VSS=VSS VDD=VDD I=n2729
XU2526 INVD0BWP7T $PINS ZN=n2646 VSS=VSS VDD=VDD I=n2706
XU1242 AOI31D1BWP7T $PINS B=n1978 A1=n957 ZN=n970 A2=n956 VDD=VDD A3=n955
+ VSS=VSS
XU1244 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n966 A1=n965 A2=n964 A4=n962 A3=n963
XU217 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n853 A2=n876 ZN=n14 A1=n854 A4=n298
XU1564 INR3D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1733 B2=n1203 ZN=n1607 B1=n1637
XU493 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A3=n144 A2=n345 ZN=n113 A1=n364 A4=n828
XU1288 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n698 ZN=n2312
XU199 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n622 ZN=n50 A2=n2284
XU896 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n505 A1=n1010 ZN=n586 A3=n353
XU228 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n1906 A2=n61
XU1459 NR4D1BWP7T $PINS VSS=VSS A4=n1846 VDD=VDD ZN=n1069 A3=n2251 A2=n1248
+ A1=n1068
XU2002 NR4D1BWP7T $PINS VSS=VSS A4=n1541 VDD=VDD ZN=n1545 A3=n1542 A2=n2251
+ A1=n1544
XU661 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n486 ZN=n387 A2=n794
XU453 AOI31D1BWP7T $PINS B=n156 A1=n532 ZN=n107 A2=n340 VDD=VDD A3=n355 VSS=VSS
XU387 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n119 ZN=n524 A2=n2247
XU354 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n979 ZN=n110 A2=n555
XU150 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n53 ZN=n872
XU2253 XNR4D2BWP7T $PINS A1=n1814 A2=n2079 ZN=rout<96> A3=rin<64> A4=n2082
+ VDD=VDD VSS=VSS
XU1094 OAI211D1BWP7T $PINS VSS=VSS C=n776 VDD=VDD A2=n614 ZN=n616 A1=n615
+ B=n613
XU1240 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n949 ZN=n951 A1=n950 A3=n948 A4=n947
XU909 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n990 A2=n984 ZN=n577 A1=n368 A4=n924
XU926 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n596 A1=n741 A2=n12 A3=n617
XU994 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n2312 A2=n750 ZN=n1977 A1=n177
+ A4=n703
XU311 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n215 ZN=n1889
XU1116 INR4D1BWP7T $PINS ZN=n655 A1=n654 B3=n1905 B2=n652 VDD=VDD B1=n653
+ VSS=VSS
XU1784 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1220 A1=n1219 A2=n1475 A4=n1574
+ A3=n1269
XU139 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2284 A2=n567 ZN=n306
XU340 NR3D1BWP7T $PINS A3=n210 VSS=VSS VDD=VDD A1=n288 A2=n319 ZN=n656
XU2125 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1809 A1=n1807 A3=n1805 A2=n1806
XU880 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n990 A1=n843 ZN=n2023 A3=n497
XU320 INVD1BWP7T $PINS ZN=n288 VSS=VSS VDD=VDD I=n854
XU454 AOI21D2BWP7T $PINS A2=n859 A1=n996 ZN=n1007 VDD=VDD B=n107 VSS=VSS
XU119 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n186 ZN=n29 A2=n461
XU515 OAI21D2BWP7T $PINS B=n827 A2=n869 ZN=n502 VDD=VDD A1=n818 VSS=VSS
XU118 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2 A2=n516 ZN=n186
XU602 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1916 ZN=n892
XU415 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n97 ZN=n554 A2=n2218
XU1365 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n581 ZN=n1433 A2=n485
XU329 AOI31D0BWP7T $PINS B=n1890 ZN=n77 A1=n73 A2=n72 VDD=VDD A3=n71 VSS=VSS
XU333 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n77 ZN=n78 A1=n677 A3=n76 A4=n195
XU1192 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2003 ZN=n852 A1=n849 A3=n826
+ A4=n825
XU2178 NR4D0BWP7T $PINS VSS=VSS A4=n1927 VDD=VDD ZN=n1919 A3=n1905 A2=n1906
+ A1=n1907
XU2181 AOI31D1BWP7T $PINS B=n1916 ZN=n1920 A1=n2039 A2=n1918 VDD=VDD A3=n1917
+ VSS=VSS
XU2182 AOI221D1BWP7T $PINS B2=n1922 A1=n1923 A2=n1922 ZN=n1932 B1=n1921 VDD=VDD
+ C=n1920 VSS=VSS
XU2174 NR4D1BWP7T $PINS VSS=VSS A4=n1889 VDD=VDD ZN=n1895 A3=n1890 A2=n1891
+ A1=n1892
XU1257 AOI31D1BWP7T $PINS B=n1005 ZN=n1020 A1=n1008 A2=n1007 VDD=VDD A3=n1006
+ VSS=VSS
XU1254 AOI31D1BWP7T $PINS B=n2051 ZN=n1021 A1=n997 A2=n2010 VDD=VDD A3=n2677
+ VSS=VSS
XU1249 AOI31D1BWP7T $PINS B=n980 ZN=n1022 A1=n983 A2=n982 VDD=VDD A3=n981
+ VSS=VSS
XU1245 AOI31D0BWP7T $PINS B=n1947 ZN=n969 A1=n968 A2=n967 VDD=VDD A3=n966
+ VSS=VSS
XU1239 AOI31D0BWP7T $PINS B=n1968 ZN=n971 A1=n946 A2=n945 VDD=VDD A3=n944
+ VSS=VSS
XU1246 NR4D0BWP7T $PINS VSS=VSS A4=n969 VDD=VDD ZN=n2062 A3=n970 A2=n971
+ A1=n972
XU1450 NR4D1BWP7T $PINS VSS=VSS A4=n1063 VDD=VDD ZN=n1078 A3=n94 A2=n2066
+ A1=n1795
XU1467 NR4D1BWP7T $PINS VSS=VSS A4=n1074 VDD=VDD ZN=n1077 A3=n1553 A2=n1390
+ A1=n1542
XU1333 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1073 ZN=n1579 A2=n1039
XU1352 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1548 B1=n2088 B2=n1807 B3=n1368
+ ZN=n1045
XU1389 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2684 ZN=n1049 A3=n1357 A2=n439
+ A1=n1048
XU1412 IND4D0BWP7T $PINS VSS=VSS A1=n1459 VDD=VDD B1=n1240 B2=n1065 B3=n1051
+ ZN=n1052
XU1413 NR4D1BWP7T $PINS VSS=VSS A4=n1052 VDD=VDD ZN=n1054 A3=n1284 A2=n1479
+ A1=n1537
XU2030 NR4D1BWP7T $PINS VSS=VSS A4=n1598 VDD=VDD ZN=n1605 A3=n1599 A2=n1600
+ A1=n1683
XU2074 NR4D1BWP7T $PINS VSS=VSS A4=n1672 VDD=VDD ZN=n1676 A3=n1673 A2=n1674
+ A1=n1749
XU1468 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1076 ZN=n1808 A2=n1075
XU601 MUX2ND1BWP7T $PINS ZN=n1936 I1=n2081 I0=n1426 S=n1902 VDD=VDD VSS=VSS
XU637 AOI22D1BWP7T $PINS B1=n1786 A2=n2777 ZN=n414 A1=n1452 VDD=VDD B2=n1461
+ VSS=VSS
XU2244 MAOI22D1BWP7T $PINS A2=n1468 ZN=n2095 A1=n2069 B2=n2069 VDD=VDD B1=n1468
+ VSS=VSS
XU135 OAI211D2BWP7T $PINS A2=n1933 ZN=n2413 A1=n2495 B=n1886 VDD=VDD C=n2130
+ VSS=VSS
XU2261 MAOI22D2BWP7T $PINS A2=n2413 ZN=n2102 A1=n2357 B2=n2357 VDD=VDD B1=n2413
+ VSS=VSS
XU2256 MAOI22D2BWP7T $PINS A2=n1434 ZN=n2099 A1=n1814 B2=n1814 VDD=VDD B1=n1434
+ VSS=VSS
XU2246 MAOI22D2BWP7T $PINS A2=n2602 ZN=n2075 A1=n1785 B2=n1785 VDD=VDD B1=n2602
+ VSS=VSS
XU746 NR4D2BWP7T $PINS VSS=VSS A4=n230 VDD=VDD ZN=n273 A3=n231 A2=n244 A1=n744
XU2212 MUX2ND1BWP7T $PINS ZN=n1990 I1=n2702 I0=n2723 S=n2602 VDD=VDD VSS=VSS
XU917 MUX2ND1BWP7T $PINS ZN=n1029 I1=n2785 I0=n1638 S=n2081 VDD=VDD VSS=VSS
XU961 AOI31D2BWP7T $PINS B=n1968 ZN=n411 A1=n401 A2=n601 VDD=VDD A3=n400
+ VSS=VSS
XU936 AOI31D2BWP7T $PINS B=n1961 ZN=n413 A1=n394 A2=n490 VDD=VDD A3=n391
+ VSS=VSS
XU970 NR4D2BWP7T $PINS VSS=VSS A4=n410 VDD=VDD ZN=n1028 A3=n411 A2=n412 A1=n413
XU1264 MUX2ND1BWP7T $PINS ZN=n1989 I1=n1815 I0=n1814 S=n1025 VDD=VDD VSS=VSS
XU1143 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1316 ZN=n767 A1=n707 A3=n753
+ A4=n706
XU1053 MUX2ND1BWP7T $PINS ZN=n1031 I1=n2081 I0=n1426 S=n1519 VDD=VDD VSS=VSS
XU351 MUX2ND1BWP7T $PINS ZN=n1033 I1=n1815 I0=n1814 S=n920 VDD=VDD VSS=VSS
XU2167 AOI22D1BWP7T $PINS B1=n2081 A2=n1426 ZN=n2078 A1=n2774 VDD=VDD B2=n1885
+ VSS=VSS
XU2027 AOI22D0BWP7T $PINS B1=n1719 A2=n1723 ZN=n1593 A1=n1715 VDD=VDD B2=n2776
+ VSS=VSS
XU1834 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2605 A2=n1363 Z=n2128
XU2161 MAOI22D1BWP7T $PINS A2=n2412 ZN=n2107 A1=n2617 B2=n2617 VDD=VDD B1=n2412
+ VSS=VSS
XU2063 AOI22D1BWP7T $PINS B1=n2412 A2=n2336 ZN=n1657 A1=n2489 VDD=VDD B2=n2333
+ VSS=VSS
XU2032 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2327 ZN=n1655 A1=n2663 A3=n1605
+ A4=n1604
XU2050 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1654 A2=n1655 A1=n1741 ZN=n2105
+ C=n1653
XU2053 AOI22D1BWP7T $PINS B1=n2356 A2=n2454 ZN=n1793 A1=n1493 VDD=VDD B2=n1480
+ VSS=VSS
XU1997 OAI22D0BWP7T $PINS B1=n1528 A2=n1708 ZN=n1530 A1=n1529 VDD=VDD B2=n1675
+ VSS=VSS
XU1985 AOI31D0BWP7T $PINS B=n1623 ZN=n1531 A1=n1503 A2=n1502 VDD=VDD A3=n1501
+ VSS=VSS
XU2075 AOI31D0BWP7T $PINS B=n1675 ZN=n1711 A1=n1829 A2=n2022 VDD=VDD A3=n1676
+ VSS=VSS
XU2085 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n2155 A2=n2660 A1=n1771 ZN=n1856
+ C=n2146
XU2112 AOI22D2BWP7T $PINS B1=n1480 A2=n1493 ZN=n1872 A1=n1911 VDD=VDD B2=n1394
+ VSS=VSS
XU1720 AOI31D2BWP7T $PINS B=n1675 ZN=n1168 A1=n1176 A2=n1233 VDD=VDD A3=n1157
+ VSS=VSS
XU1730 NR4D4BWP7T $PINS VSS=VSS A4=n1167 VDD=VDD ZN=n1938 A3=n1168 A2=n1169
+ A1=n1170
XU2191 MAOI22D1BWP7T $PINS A2=n1317 ZN=n2119 A1=n1606 B2=n1606 VDD=VDD B1=n1317
+ VSS=VSS
XU2164 AOI22D2BWP7T $PINS B1=n2608 A2=n2355 ZN=n1940 A1=sout1<28> VDD=VDD
+ B2=n1706 VSS=VSS
XU2150 IAO22D2BWP7T $PINS A2=n2605 ZN=n2121 A1=n1914 B2=n1914 VDD=VDD B1=n2605
+ VSS=VSS
XU2134 AOI31D2BWP7T $PINS B=n1836 ZN=n1852 A1=n2709 A2=n1838 VDD=VDD A3=n1837
+ VSS=VSS
XU2130 AOI21D2BWP7T $PINS VSS=VSS A2=n1825 VDD=VDD A1=n2790 B=n1824 ZN=n1853
XU2126 AOI31D2BWP7T $PINS B=n1808 ZN=n1854 A1=n1811 A2=n1810 VDD=VDD A3=n1809
+ VSS=VSS
XU2138 NR4D4BWP7T $PINS VSS=VSS A4=n1956 VDD=VDD ZN=n2106 A3=n1852 A2=n1853
+ A1=n1854
XU1913 AOI31D0BWP7T $PINS B=n1808 ZN=n1384 A1=n2790 A2=n1361 VDD=VDD A3=n1360
+ VSS=VSS
XU1905 IND4D0BWP7T $PINS VSS=VSS A1=n1372 VDD=VDD B1=n1407 B2=n1359 B3=n1352
+ ZN=n1385
XU1926 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n2154 A2=n1385 A1=n1490 ZN=n1864
+ C=n62
XU2115 MUX2ND1BWP7T $PINS ZN=n2113 I1=n1723 I0=n1719 S=n2721 VDD=VDD VSS=VSS
XU2116 AOI22D2BWP7T $PINS B1=n2348 A2=n2472 ZN=n1876 A1=n1493 VDD=VDD B2=n1480
+ VSS=VSS
XU1959 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1443 ZN=n1489 A1=n1444 A3=n1442
+ A4=n2256
XU1976 AOI21D2BWP7T $PINS VSS=VSS A2=n1991 VDD=VDD A1=n1490 B=n1893 ZN=n1869
XU2140 AOI22D2BWP7T $PINS B1=n2356 A2=n2454 ZN=n1868 A1=n1914 VDD=VDD B2=n1471
+ VSS=VSS
XU2003 AOI31D1BWP7T $PINS B=n1808 ZN=n1591 A1=n1547 A2=n1546 VDD=VDD A3=n1545
+ VSS=VSS
XU2017 NR4D0BWP7T $PINS VSS=VSS A4=n1588 VDD=VDD ZN=n2001 A3=n2138 A2=n1590
+ A1=n1591
XU2217 AOI22D2BWP7T $PINS B1=sout1<13> A2=n1348 ZN=n2000 A1=n1914 VDD=VDD
+ B2=n1471 VSS=VSS
XU619 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n202 A1=n886 A2=n287 A4=n636 A3=n285
XU2406 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n2526 A1=n675 A2=n886 A4=n214 A3=n10
XU1941 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1405 A1=n1403 A2=n1402 A4=n1835
+ A3=n2540
XU1743 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2087 ZN=n1600
XU2089 XNR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n1714 A3=rin<19> ZN=rout<51>
+ A2=n1866 A1=n1877
XU2238 XNR4D2BWP7T $PINS VSS=VSS VDD=VDD A4=n2057 A3=n2059 ZN=rout<103>
+ A2=n2602 A1=n2069
XU2141 AOI22D1BWP7T $PINS ZN=n1859 A1=n1911 A2=n1328 B2=n1394 VDD=VDD B1=n1317
+ VSS=VSS
XU609 NR4D0BWP7T $PINS VSS=VSS A4=n1994 VDD=VDD ZN=n194 A3=n192 A2=n858
+ A1=n1053
XU968 NR4D1BWP7T $PINS VSS=VSS A4=n408 VDD=VDD ZN=n409 A3=n963 A2=n728 A1=n724
XU1110 NR4D1BWP7T $PINS VSS=VSS A4=n636 VDD=VDD ZN=n642 A3=n637 A2=n1053
+ A1=n900
XU334 OAI31D1BWP7T $PINS B=n1928 A3=n78 ZN=n91 A2=n322 VDD=VDD A1=n1305 VSS=VSS
XU1217 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2330 ZN=n907 A1=n897 A3=n895
+ A4=n894
XU1184 OAI211D1BWP7T $PINS VSS=VSS C=n1954 VDD=VDD A2=n806 ZN=n811 A1=n1101
+ B=n805
XU1243 OAI211D1BWP7T $PINS VSS=VSS C=n1288 VDD=VDD A2=n1102 ZN=n962 A1=n961
+ B=n959
XU920 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2324 ZN=n941 A1=n403 A3=n720
+ A4=n2313
XU727 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1091 ZN=n755 A2=n911
XU829 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1102 ZN=n953 A2=n911
XU663 AOI21D2BWP7T $PINS VSS=VSS A2=n1047 VDD=VDD A1=n773 B=n1091 ZN=n390
XU781 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n727 ZN=n949 A2=n929
XU940 NR4D1BWP7T $PINS VSS=VSS A4=n392 VDD=VDD ZN=n406 A3=n781 A2=n942 A1=n791
XU810 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1101 ZN=n724 A2=n2244
XU788 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n473 ZN=n239 A1=n238 A3=n691 A4=n2308
XU789 NR3D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1980 A1=n257 A3=n239 A2=n735
XU966 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n776 ZN=n963 A1=n2312 A3=n701
+ A4=n1218
XU1124 NR4D1BWP7T $PINS VSS=VSS A4=n857 VDD=VDD ZN=n676 A3=n899 A2=n674 A1=n675
XU747 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<126> A2=n2112 Z=n268
XU1152 NR4D1BWP7T $PINS VSS=VSS A4=n728 VDD=VDD ZN=n732 A3=n729 A2=n964 A1=n730
XU1153 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n732 A1=n967 ZN=n1958 A3=n2322
XU812 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n795 ZN=n719 A2=n250
XU1144 AO211D1BWP7T $PINS Z=n952 C=n708 B=n709 A2=n710 VDD=VDD A1=n2769 VSS=VSS
XU440 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<119> A2=rk0<23> ZN=n133
XU881 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2278 ZN=n337 A1=n821 A3=n346 A4=n336
XU882 NR4D3BWP7T $PINS VSS=VSS A4=n2158 VDD=VDD ZN=n834 A3=n2023 A2=n338
+ A1=n840
XU485 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2266 ZN=n507 A2=n782
XU576 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n156 ZN=n506 A2=n817
XU1247 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n975 ZN=n976 A1=n2005 A3=n974
+ A4=n973
XU1248 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n2067 A2=n978 A1=n979 ZN=n981
+ C=n976
XU1255 IIND4D0BWP7T $PINS VSS=VSS A1=n1001 VDD=VDD ZN=n1002 B1=n999 B2=n2293
+ A2=n1000
XU1256 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2008 B1=n1004 B2=n1003 B3=n1002
+ ZN=n1006
XU1096 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n720 ZN=n629 A1=n2669 A3=n618
+ A4=n617
XU1104 NR4D1BWP7T $PINS VSS=VSS A4=n628 VDD=VDD ZN=n631 A3=n629 A2=n630 A1=n796
XU1085 NR4D1BWP7T $PINS VSS=VSS A4=n595 VDD=VDD ZN=n598 A3=n596 A2=n709 A1=n597
XU66 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk0<6> A2=rin<102> Z=sin0<6>
XU865 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n904 A1=n880 ZN=n432 A3=n310
XU978 IND4D1BWP7T $PINS VSS=VSS A1=n430 VDD=VDD B1=n429 B2=n428 B3=n1924
+ ZN=n431
XU1379 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1473 A2=n465 A1=n1254 ZN=n1043
+ C=n1058
XU1754 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1515 ZN=n1196 A1=n1195 A3=n1670
+ A4=n1724
XU1755 NR4D2BWP7T $PINS VSS=VSS A4=n1196 VDD=VDD ZN=n1739 A3=n1197 A2=n2093
+ A1=n1765
XU2047 NR4D1BWP7T $PINS VSS=VSS A4=n1646 VDD=VDD ZN=n1648 A3=n1730 A2=n1761
+ A1=n1647
XU1757 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1199 ZN=n1634 A1=n163 A3=n1198
+ A4=n2087
XU1520 NR2D2P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2204 ZN=n1628 A2=n1717
XU1555 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2253 ZN=n1637 A2=n2238
XU74 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<30> A2=rin<62> Z=sin1<30>
XU1535 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<54> A2=rk1<22> Z=n1116
XU1744 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1180 ZN=n1491 A1=n1181 A3=n1737
+ A4=n1615
XU1710 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1631 A1=n163 ZN=n1527 A3=n1149
XU1698 NR4D1BWP7T $PINS VSS=VSS A4=n1504 VDD=VDD ZN=n1140 A3=n1760 A2=n1498
+ A1=n1139
XU1537 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<55> A2=rk1<23> Z=n1117
XU1725 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n2305 ZN=n1339 A1=n2087 A3=n2270
+ A4=n1731
XU1724 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1740 ZN=n1694 A1=n1516 A3=n1161
+ A4=n1699
XU1870 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1737 ZN=n1308 A3=n1303 A2=n1304
+ A1=n2203
XU1842 NR4D1BWP7T $PINS VSS=VSS A4=n1275 VDD=VDD ZN=n1277 A3=n1276 A2=n1577
+ A1=n1537
XU1794 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1231 ZN=n1794 A2=n889
XU1970 NR4D1BWP7T $PINS VSS=VSS A4=n1472 VDD=VDD ZN=n1801 A3=n1473 A2=n1474
+ A1=n1475
XU1815 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1402 A2=n608 A1=n1290 ZN=n1816
+ C=n1243
XU1866 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1361 ZN=n1845 A1=n1410 A3=n1833
+ A4=n1349
XU1901 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1576 A2=n1347 A1=n474 ZN=n1407
+ C=n1346
XU1361 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1797 ZN=n1380 A2=n1459
XU1914 OAI211D2BWP7T $PINS A2=n1362 ZN=n1371 A1=n367 B=n1463 VDD=VDD C=n1406
+ VSS=VSS
XU1766 NR4D0BWP7T $PINS VSS=VSS A4=n1504 VDD=VDD ZN=n1210 A3=n1158 A2=n1647
+ A1=n1209
XU2091 AOI31D1BWP7T $PINS B=n1716 ZN=n1726 A1=n2204 A2=n1718 VDD=VDD A3=n1717
+ VSS=VSS
XU2094 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1727 ZN=n1778 A3=n1728 A2=n1729
+ A1=n1730
XU2106 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1771 ZN=n1775 A3=n1772 A2=n1773
+ A1=n1774
XU2102 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1756 ZN=n1776 A3=n1757 A2=n1758
+ A1=n1759
XU1966 AOI31D1BWP7T $PINS B=n1460 ZN=n1464 A1=n421 A2=n1462 VDD=VDD A3=n638
+ VSS=VSS
XU1824 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1392 A2=n1253 A1=n1254 ZN=n1255
+ C=n1533
XU1315 ND3D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1347 A1=n1048 ZN=n1438 A3=n367
XU1956 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1435 ZN=n1844 A1=n1436 A3=n2240
+ A4=n1453
XU1918 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1444 A1=n2224 A3=n1367 A2=n1368
XU1366 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2226 ZN=n1554 A2=n1374
XU1273 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<39> A2=rk1<7> Z=n1075
XU1848 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1572 A1=n1828 A3=n1552 A2=n1281
XU2009 OAI211D1BWP7T $PINS A2=n1562 ZN=n1564 A1=n1563 B=n1561 VDD=VDD C=n1560
+ VSS=VSS
XU2010 NR4D1BWP7T $PINS VSS=VSS A4=n1564 VDD=VDD ZN=n1573 A3=n1565 A2=n1566
+ A1=n1567
XU543 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2045 ZN=n136 A3=n135 A2=n2047
+ A1=n518
XU497 OAI31D0BWP7T $PINS VSS=VSS VDD=VDD B=n544 ZN=n138 A3=n113 A2=n2017
+ A1=n114
XU445 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2029 A1=n500 ZN=n139 A2=n105
XU1183 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n804 B1=n803 B2=n802 B3=n801
+ ZN=n813
XU1016 AOI31D2BWP7T $PINS B=n1968 ZN=n492 A1=n482 A2=n957 VDD=VDD A3=n481
+ VSS=VSS
XU1006 AOI31D2BWP7T $PINS B=n1978 ZN=n493 A1=n1971 A2=n466 VDD=VDD A3=n2654
+ VSS=VSS
XU999 AOI31D2BWP7T $PINS B=n1961 ZN=n494 A1=n707 A2=n2152 VDD=VDD A3=n458
+ VSS=VSS
XU1021 NR4D3BWP7T $PINS VSS=VSS A4=n491 VDD=VDD ZN=n1026 A3=n492 A2=n493
+ A1=n494
XU1073 NR4D0BWP7T $PINS VSS=VSS A4=n576 VDD=VDD ZN=n588 A3=n577 A2=n578
+ A1=n2019
XU1077 NR4D0BWP7T $PINS VSS=VSS A4=n585 VDD=VDD ZN=n587 A3=n586 A2=n845 A1=n829
XU1069 AOI31D1BWP7T $PINS B=n980 ZN=n590 A1=n573 A2=n2003 VDD=VDD A3=n572
+ VSS=VSS
XU1065 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n562 ZN=n591 A1=n836 A3=n561 A4=n560
XU335 OAI211D1BWP7T $PINS A2=n80 ZN=n89 A1=n890 B=n79 VDD=VDD C=n677 VSS=VSS
XU321 NR4D1BWP7T $PINS VSS=VSS A4=n1927 VDD=VDD ZN=n65 A3=n305 A2=n288 A1=n674
XU322 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n903 ZN=n67 A1=n665 A3=n66 A4=n65
XU91 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n39 ZN=n1922 A2=n25
XU195 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n901 A1=n203 ZN=n322 A3=n11
XU332 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n196 B1=n75 B2=n1927 B3=n884 ZN=n76
XU2033 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n1637 A2=n1628 A1=n792 ZN=n1625
+ C=n1608
XU947 AOI31D2BWP7T $PINS B=n1947 ZN=n412 A1=n406 A2=n1981 VDD=VDD A3=n395
+ VSS=VSS
XU2013 NR4D1BWP7T $PINS VSS=VSS A4=n1574 VDD=VDD ZN=n1587 A3=n1575 A2=n1576
+ A1=n1577
XU1117 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A3=n655 A2=n656 ZN=n1898 A1=n657
+ A4=n867
XU617 AOI31D1BWP7T $PINS B=n2314 ZN=n222 A1=n442 A2=n205 VDD=VDD A3=n193
+ VSS=VSS
XU1469 OAI22D1BWP7T $PINS ZN=n1079 A1=n1078 A2=n459 B2=n1808 VDD=VDD B1=n1077
+ VSS=VSS
XU2016 AOI21D0BWP7T $PINS VSS=VSS A2=n1586 VDD=VDD A1=n1587 B=n1824 ZN=n1588
XU1215 OAI211D1BWP7T $PINS A2=n622 ZN=n891 A1=n890 B=n888 VDD=VDD C=n887
+ VSS=VSS
XU1929 AOI22D1BWP7T $PINS ZN=n1873 A1=sout1<15> A2=n2489 B2=n1355 VDD=VDD
+ B1=n2333 VSS=VSS
XU1216 AOI22D0BWP7T $PINS B1=n892 A2=n893 ZN=n909 A1=n1922 VDD=VDD B2=n891
+ VSS=VSS
XU1128 AOI22D0BWP7T $PINS B1=sout0<7> A2=n1742 ZN=n686 A1=n1452 VDD=VDD
+ B2=n1461 VSS=VSS
XU1265 MUX2ND1BWP7T $PINS ZN=n1034 I1=n2079 I0=n1027 S=n1026 VDD=VDD VSS=VSS
XU2240 AOI22D2BWP7T $PINS ZN=n2101 A1=n2691 A2=sout0<7> B2=n2353 VDD=VDD
+ B1=n1742 VSS=VSS
XU2257 MAOI22D2BWP7T $PINS VSS=VSS VDD=VDD B2=n1603 B1=n2781 ZN=n2092 A1=n1603
+ A2=n2781
XU2198 AOI22D1BWP7T $PINS B1=n1787 A2=n1790 ZN=n1987 A1=n2361 VDD=VDD B2=n2601
+ VSS=VSS
XU2273 XNR4D2BWP7T $PINS A1=n2124 A2=n1914 ZN=rout<61> A3=rin<29> A4=n2116
+ VDD=VDD VSS=VSS
XU2020 CKXOR2D2BWP7T $PINS A1=n2115 VDD=VDD VSS=VSS A2=n1592 Z=rout<59>
XU2110 CKXOR2D2BWP7T $PINS A1=n1884 VDD=VDD VSS=VSS A2=n1781 Z=rout<50>
XU1063 NR4D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n2042 A1=n557 A2=n1012 A4=n556
+ A3=n2320
XU229 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n305 ZN=n189 A2=n1906
XU1220 OAI31D1BWP7T $PINS B=n1928 A3=n906 ZN=n908 A2=n149 VDD=VDD A1=n907
+ VSS=VSS
XU2229 OAI31D1BWP7T $PINS B=n2029 A3=n2030 ZN=n2050 A2=n2040 VDD=VDD A1=n2032
+ VSS=VSS
XU2228 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n2275 A2=n2027 ZN=n2030 A1=n2028
+ A4=n1092
XU1003 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1953 ZN=n480 A1=n594 A3=n624
+ A4=n2308
XU418 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n150 ZN=n98 A3=n525 A2=n2218 A1=n176
XU434 IND4D1BWP7T $PINS VSS=VSS A1=n2004 VDD=VDD B1=n102 B2=n101 B3=n336
+ ZN=n165
XU608 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2330 ZN=n326 A1=n1098 A3=n315
+ A4=n209
XU2397 OAI211D0BWP7T $PINS A2=n342 ZN=n2517 A1=n340 B=n339 VDD=VDD C=n524
+ VSS=VSS
XU164 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2209 ZN=n38 A2=n644
XU315 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n417 ZN=n210 A2=n61
XU134 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n29 ZN=n214 A2=n80
XU1198 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n842 ZN=n844 A1=n843 A3=n2294
+ A4=n841
XU1199 NR4D0BWP7T $PINS VSS=VSS A4=n844 VDD=VDD ZN=n847 A3=n845 A2=n2047
+ A1=n846
XU901 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n357 ZN=n838 A2=n356
XU97 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n73 ZN=n276 A2=n53
XU930 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2307 A1=n1102 ZN=n592 A2=n806
XU175 NR4D1BWP7T $PINS VSS=VSS A4=n1930 VDD=VDD ZN=n668 A3=n21 A2=n317 A1=n287
XU1145 INR3D1BWP7T $PINS VSS=VSS VDD=VDD A1=n757 B2=n711 ZN=n805 B1=n965
XU669 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n745 ZN=n237 A2=n224
XU1034 AOI21D2BWP7T $PINS VSS=VSS A2=n818 VDD=VDD A1=n532 B=n869 ZN=n556
XU1252 IND4D0BWP7T $PINS VSS=VSS A1=n992 VDD=VDD B1=n991 B2=n990 B3=n989
+ ZN=n1000
XU535 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n519 ZN=n130 A1=n129 A3=n372 A4=n174
XU536 NR4D2BWP7T $PINS VSS=VSS A4=n130 VDD=VDD ZN=n1017 A3=n2165 A2=n995
+ A1=n369
XU618 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n878 A1=n318 ZN=n636 A3=n881
XU1579 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1663 ZN=n1115 A2=n2805
XU1852 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1409 B=n1828 A2=n1375 A1=n476
XU1786 AOI21D2BWP7T $PINS VSS=VSS A2=n889 VDD=VDD A1=n581 B=n1562 ZN=n1397
XU1844 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1279 ZN=n1454 A2=n1417
XU87 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<9> A2=rin<41> Z=sin1<9>
XU721 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n694 ZN=n783 A2=n1951
XU2206 NR4D1BWP7T $PINS VSS=VSS A4=n2626 VDD=VDD ZN=n1969 A3=n1965 A2=n1966
+ A1=n1967
XU275 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n443 A1=n327 A3=n37 A2=n302
XU848 NR4D1BWP7T $PINS VSS=VSS A4=n430 VDD=VDD ZN=n284 A3=n277 A2=n305 A1=n278
XU857 NR4D0BWP7T $PINS VSS=VSS A4=n291 VDD=VDD ZN=n294 A3=n1913 A2=n647 A1=n292
XU854 NR4D0BWP7T $PINS VSS=VSS A4=n285 VDD=VDD ZN=n295 A3=n286 A2=n306 A1=n287
XU442 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<118> A2=rk0<22> ZN=n122
XU557 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n564 A2=n571 A1=n533 ZN=n351
+ C=n180
XU582 IINR4D1BWP7T $PINS VSS=VSS A1=n542 VDD=VDD ZN=n522 B1=n2037 B2=n564
+ A2=n999
XU574 NR4D1BWP7T $PINS VSS=VSS A4=n155 VDD=VDD ZN=n2012 A3=n374 A2=n1004
+ A1=n496
XU579 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n2021 A2=n731 A1=n370 ZN=n158
+ C=n157
XU615 NR4D1BWP7T $PINS VSS=VSS A4=n199 VDD=VDD ZN=n201 A3=n213 A2=n200 A1=n1907
XU141 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n306 ZN=n657 A2=n75
XU907 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2033 B1=n366 B2=n586 B3=n365
+ ZN=n376
XU893 NR4D1BWP7T $PINS VSS=VSS A4=n349 VDD=VDD ZN=n350 A3=n518 A2=n2019 A1=n1
XU887 AOI31D1BWP7T $PINS B=n2804 ZN=n343 A1=n869 A2=n342 VDD=VDD A3=n525
+ VSS=VSS
XU886 OAI211D1BWP7T $PINS A2=n342 ZN=n2031 A1=n340 B=n339 VDD=VDD C=n524
+ VSS=VSS
XU149 AOI21D2BWP7T $PINS VSS=VSS A2=n873 VDD=VDD A1=n185 B=n1061 ZN=n905
XU285 NR4D0BWP7T $PINS VSS=VSS A4=n279 VDD=VDD ZN=n47 A3=n191 A2=n184 A1=n75
XU142 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1910 ZN=n858 A2=n2284
XU261 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n900 A2=n29
XU233 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n51 ZN=n866 A1=n189 A3=n195 A4=n209
XU292 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1244 ZN=n1909 A2=n50
XU1214 NR4D2BWP7T $PINS VSS=VSS A4=n883 VDD=VDD ZN=n887 A3=n884 A2=n885 A1=n886
XU117 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n1915 A2=n1046
XU326 NR4D1BWP7T $PINS VSS=VSS A4=n68 VDD=VDD ZN=n206 A3=n430 A2=n313 A1=n69
XU299 IND4D2BWP7T $PINS VSS=VSS A1=n312 VDD=VDD B1=n654 B2=n2315 B3=n672
+ ZN=n647
XU294 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n442 A1=n882 A3=n433 A2=n1899
XU791 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n808 B1=n748 B2=n603 B3=n777 ZN=n240
XU825 OAI211D1BWP7T $PINS A2=n773 ZN=n270 A1=n470 B=n1954 VDD=VDD C=n750
+ VSS=VSS
XU840 NR4D1BWP7T $PINS VSS=VSS A4=n265 VDD=VDD ZN=n1949 A3=n726 A2=n607 A1=n380
XU89 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<110> A2=rk0<14> Z=n39
XU739 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n615 ZN=n1950 A2=n2243
XU1519 INVD0BWP7T $PINS ZN=n1318 VSS=VSS VDD=VDD I=n1085
XU70 CKXOR2D2BWP7T $PINS A1=rk0<2> VDD=VDD VSS=VSS A2=rin<98> Z=sin0<2>
XU42 INVD1BWP7T $PINS ZN=n2207 VSS=VSS VDD=VDD I=n555
XU1325 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n367 ZN=n1254 A2=n439
XU1521 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2203 ZN=n1523 A2=n1628
XU67 CKXOR2D2BWP7T $PINS A1=rk0<5> VDD=VDD VSS=VSS A2=rin<101> Z=sin0<5>
XU72 CKXOR2D2BWP7T $PINS A1=n2571 VDD=VDD VSS=VSS A2=rin<96> Z=sin0<0>
XU68 CKXOR2D4BWP7T $PINS A1=rk0<4> VDD=VDD VSS=VSS A2=rin<100> Z=sin0<4>
XU1319 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1439 ZN=n1446 A2=n1040
XU1302 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1048 ZN=n1241 A2=n1580
XU1309 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1462 ZN=n1374 A2=n1290
XU1498 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1085 ZN=n1698 A2=n407
XU365 CKND0BWP7T $PINS ZN=n2238 VSS=VSS VDD=VDD I=n1107
XU1330 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1347 ZN=n1217 A2=n1375
XU1501 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1698 ZN=n1608 A2=n2238
XU431 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n530 ZN=n355 A2=n512
XU1285 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1048 ZN=n1563 A2=n1830
XU1562 INVD0BWP7T $PINS ZN=n1134 VSS=VSS VDD=VDD I=n1612
XU128 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n2 A2=n774 ZN=n23
XU1438 INVD1BWP7T $PINS ZN=n1456 VSS=VSS VDD=VDD I=n1058
XU1444 INVD1BWP7T $PINS ZN=n1388 VSS=VSS VDD=VDD I=n1469
XU152 INVD0BWP7T $PINS ZN=n18 VSS=VSS VDD=VDD I=n33
XU377 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n242 ZN=n2243
XU133 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n72 ZN=n80 A2=n7
XU143 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n5 ZN=n61 A2=n186
XU533 INVD1BWP7T $PINS ZN=n369 VSS=VSS VDD=VDD I=n2011
XU1578 INVD1BWP7T $PINS ZN=n1507 VSS=VSS VDD=VDD I=n1666
XU1795 INVD1BWP7T $PINS ZN=n1577 VSS=VSS VDD=VDD I=n1235
XU759 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n35 ZN=n2284
XU168 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n57 ZN=n200 A2=n417
XU1132 INVD1BWP7T $PINS ZN=n2308 VSS=VSS VDD=VDD I=n964
XU1581 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1125 A1=n1626 A3=n1151 A2=n1115
XU1681 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1636 ZN=n1701 A2=n1621
XU1462 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n1430 ZN=n1576
XU1396 OAI21D2BWP7T $PINS B=n1848 A2=n1563 ZN=n1390 VDD=VDD A1=n485 VSS=VSS
XU404 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n818 A2=n566 ZN=n1004
XU411 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n153 A2=n818 ZN=n840
XU741 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2243 ZN=n729 A2=n1083
XU1354 INVD1BWP7T $PINS ZN=n1068 VSS=VSS VDD=VDD I=n1799
XU381 INVD1BWP7T $PINS ZN=n557 VSS=VSS VDD=VDD I=n372
XU1516 NR4D0BWP7T $PINS VSS=VSS A4=n1704 VDD=VDD ZN=n1084 A3=n1599 A2=n1608
+ A1=n1765
XU230 INVD0BWP7T $PINS ZN=n51 VSS=VSS VDD=VDD I=n304
XU234 INVD0BWP7T $PINS ZN=n1891 VSS=VSS VDD=VDD I=n853
XU1391 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n2226 A2=n485 ZN=n1537
XU779 INVD0BWP7T $PINS ZN=n727 VSS=VSS VDD=VDD I=n259
XU1811 INVD1BWP7T $PINS ZN=n1361 VSS=VSS VDD=VDD I=n1239
XU259 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n29 A2=n33 ZN=n899
XU186 CKND0BWP7T $PINS ZN=n2224 VSS=VSS VDD=VDD I=n1848
XU1351 INVD0BWP7T $PINS ZN=n1368 VSS=VSS VDD=VDD I=n1072
XU1430 IND4D1BWP7T $PINS VSS=VSS A1=n1535 VDD=VDD B1=n1555 B2=n1558 B3=n1430
+ ZN=n1057
XU1472 INVD0BWP7T $PINS ZN=n2330 VSS=VSS VDD=VDD I=n286
XU556 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n143 A1=n2159 ZN=n180 A3=n142
XU1867 NR4D1BWP7T $PINS VSS=VSS A4=n1845 VDD=VDD ZN=n1297 A3=n1296 A2=n1827
+ A1=n1822
XU830 INR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n959 B1=n953 A1=n1953
XU218 NR4D0BWP7T $PINS VSS=VSS A4=n14 VDD=VDD ZN=n15 A3=n311 A2=n306 A1=n1915
XU1149 INVD1BWP7T $PINS ZN=n954 VSS=VSS VDD=VDD I=n720
XU207 INVD1BWP7T $PINS ZN=n678 VSS=VSS VDD=VDD I=n13
XU1868 AOI31D1BWP7T $PINS B=n1836 ZN=n1299 A1=n1408 A2=n1298 VDD=VDD A3=n1297
+ VSS=VSS
XU1823 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1479 ZN=n1810 A2=n1252
XU1888 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1500 A1=n1329 ZN=n1774 A3=n2252
XU1017 NR4D1BWP7T $PINS VSS=VSS A4=n1966 VDD=VDD ZN=n484 A3=n593 A2=n719
+ A1=n483
XU444 INVD1BWP7T $PINS ZN=n2029 VSS=VSS VDD=VDD I=n1005
XU1027 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n582 A1=n849 ZN=n546 A3=n504
XU1920 NR4D1BWP7T $PINS VSS=VSS A4=n1370 VDD=VDD ZN=n1382 A3=n1371 A2=n1372
+ A1=n1373
XU523 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2055 A1=n569 ZN=n137 A2=n123
XU921 NR4D2BWP7T $PINS VSS=VSS A4=n941 VDD=VDD ZN=n394 A3=n711 A2=n1950 A1=n380
XU2233 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n2045 ZN=n2049 A3=n2046 A2=n2047
+ A1=n2048
XU794 INVD0BWP7T $PINS ZN=n930 VSS=VSS VDD=VDD I=n1961
XU1148 NR4D1BWP7T $PINS VSS=VSS A4=n717 VDD=VDD ZN=n765 A3=n952 A2=n718 A1=n719
XU185 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n657 ZN=n46 A1=n659 A3=n171 A4=n1901
XU1020 AOI31D2BWP7T $PINS B=n1947 ZN=n491 A1=n490 A2=n2503 VDD=VDD A3=n488
+ VSS=VSS
XU1461 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1817 ZN=n1553 A1=n1070 A3=n1069
+ A4=n1453
XU1163 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n760 ZN=n763 A3=n761 A2=n762
+ A1=n954
XU959 NR4D1BWP7T $PINS VSS=VSS A4=n399 VDD=VDD ZN=n400 A3=n2334 A2=n610 A1=n797
XU1047 AOI22D1BWP7T $PINS B1=n2029 A2=n540 ZN=n549 A1=n2055 VDD=VDD B2=n539
+ VSS=VSS
XU1974 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1482 ZN=n1485 A3=n1483 A2=n1484
+ A1=n1583
XU2133 NR3D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1837 A1=n1842 A3=n1834 A2=n1835
XU1078 OAI22D1BWP7T $PINS B1=n587 A2=n2051 ZN=n589 A1=n2143 VDD=VDD B2=n1015
+ VSS=VSS
XU894 AOI31D1BWP7T $PINS B=n2051 A1=n351 ZN=n378 A2=n1018 VDD=VDD A3=n350
+ VSS=VSS
XU317 OAI211D1BWP7T $PINS VSS=VSS C=n1132 VDD=VDD A2=n622 ZN=n63 A1=n774
+ B=n1908
XU2081 OAI211D2BWP7T $PINS VSS=VSS C=n163 VDD=VDD A2=n1697 ZN=n1703 A1=n1698
+ B=n1696
XU300 OAI211D1BWP7T $PINS VSS=VSS C=n51 VDD=VDD A2=n1182 ZN=n54 A1=n53 B=n667
XU913 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n375 A1=n1013 A2=n577 A4=n373 A3=n374
XU1669 OAI211D1BWP7T $PINS VSS=VSS C=n2135 VDD=VDD A2=n1623 ZN=n1122 A1=n1121
+ B=n1120
XU2232 OAI211D1BWP7T $PINS VSS=VSS C=n2041 VDD=VDD A2=n2043 ZN=n2046 A1=n2044
+ B=n2042
XU260 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1046 ZN=n1927 A2=n743
XU587 ND2D1BWP7T $PINS VSS=VSS A2=n787 VDD=VDD A1=n996 ZN=n990
XU1032 OAI211D1BWP7T $PINS VSS=VSS C=n558 VDD=VDD A2=n782 ZN=n513 A1=n817
+ B=n2006
XU1180 OAI211D1BWP7T $PINS VSS=VSS C=n1974 VDD=VDD A2=n794 ZN=n802 A1=n795
+ B=n950
XU307 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n297 I=n285
XU1865 NR3D1BWP7T $PINS A3=n1295 VSS=VSS VDD=VDD A1=n1542 A2=n1584 ZN=n1408
XU944 OAI211D2BWP7T $PINS VSS=VSS C=n2312 VDD=VDD A2=n1955 ZN=n605 A1=n1091
+ B=n1316
XU1718 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1154 A2=n1699 ZN=n1716 A1=n1184
+ A4=n1737
XU1809 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1238 A1=n1537 A2=n1828 A4=n1536
+ A3=n1429
XU1011 OAI211D2BWP7T $PINS VSS=VSS C=n473 VDD=VDD A2=n475 ZN=n477 A1=n1162
+ B=n2312
XU194 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n11 A1=n10 A2=n1061 A4=n317 A3=n1060
XU363 NR2XD0BWP7T $PINS VSS=VSS A2=n357 VDD=VDD A1=n342 ZN=n361
XU713 NR2D1P5BWP7T $PINS VSS=VSS A2=n250 VDD=VDD A1=n2244 ZN=n698
XU655 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1102 ZN=n455 A2=n773
XU1572 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2272 ZN=n1762 A2=n1523
XU1569 NR2D1P5BWP7T $PINS VSS=VSS A2=n1523 VDD=VDD A1=n2253 ZN=n1626
XU1308 NR2D2BWP7T $PINS VSS=VSS A2=n1439 VDD=VDD A1=n1038 ZN=n1290
XU2400 INVD0BWP7T $PINS ZN=n2740 VSS=VSS VDD=VDD I=n2704
XU2391 INVD0BWP7T $PINS ZN=n2739 VSS=VSS VDD=VDD I=n2025
XU2365 INVD0BWP7T $PINS ZN=n2732 VSS=VSS VDD=VDD I=n1832
XU2360 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2073 Z=n2727
XU2347 INVD0BWP7T $PINS ZN=n2724 VSS=VSS VDD=VDD I=n2700
XU2342 INVD0BWP7T $PINS ZN=n2721 VSS=VSS VDD=VDD I=n2722
XU1688 INVD0BWP7T $PINS ZN=n2743 VSS=VSS VDD=VDD I=n2696
XU1540 AN4D1BWP7T $PINS VSS=VSS A1=n60 VDD=VDD A2=n59 A3=n58 A4=n297 Z=n2706
XU1388 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n1130 A3=n1131 A2=n1158 A1=n1156
+ Z=n2704
XU1322 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n871 A2=n872 A1=n873 ZN=n2703
+ C=n870
XU1221 AO211D2BWP7T $PINS Z=n2702 C=n2141 B=n590 A2=n591 VDD=VDD A1=n2029
+ VSS=VSS
XU1209 OAI31D1BWP7T $PINS B=n1756 A3=n1334 ZN=n2701 A2=n1774 VDD=VDD A1=n1335
+ VSS=VSS
XU1156 AN4D1BWP7T $PINS VSS=VSS A1=n741 VDD=VDD A2=n740 A3=n739 A4=n738 Z=n2700
XU600 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n1542 A3=n1797 A2=n1567 A1=n1236
+ Z=n2698
XU308 OA21D0BWP7T $PINS Z=n2696 A1=n1303 VDD=VDD A2=n1680 VSS=VSS B=n1084
XU82 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2589 A2=rin<46> Z=sin1<14>
XU100 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n644 ZN=n185 A2=n73
XU76 CKXOR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<28> A2=rin<60> Z=sin1<28>
XU658 NR2D3BWP7T $PINS VSS=VSS VDD=VDD ZN=n746 A1=n2560 A2=n614
XU2259 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1787 ZN=n2091 A1=n1785 B2=n1785
+ B1=n1787
XU2149 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1871 A2=n1870 Z=rout<34>
XU2236 MUX2ND1BWP7T $PINS ZN=n2059 I1=n1786 I0=n2777 S=n2727 VDD=VDD VSS=VSS
XU2189 MAOI22D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1418 ZN=n2117 A1=n2618 B2=n2618
+ B1=n1418
XU1259 NR4D1BWP7T $PINS VSS=VSS A4=n1011 VDD=VDD ZN=n1016 A3=n1012 A2=n1013
+ A1=n1014
XU2204 NR4D0BWP7T $PINS VSS=VSS A4=n1957 VDD=VDD ZN=n1962 A3=n1958 A2=n1959
+ A1=n1960
XU1033 NR3D2BWP7T $PINS A3=n513 VSS=VSS VDD=VDD A1=n2165 A2=n514 ZN=n826
XU443 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2206 ZN=n1005 A2=n122
XU1075 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n582 A1=n583 ZN=n845 A3=n828
XU500 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n818 ZN=n2019 A2=n782
XU1666 IIND4D1BWP7T $PINS VSS=VSS A1=n1673 VDD=VDD ZN=n1118 B1=n2156 B2=n1180
+ A2=n1115
XU140 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n30 ZN=n75 A2=n2161
XU1565 OAI21D2BWP7T $PINS B=n1718 A2=n683 ZN=n1129 VDD=VDD A1=n1691 VSS=VSS
XU1293 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n421 ZN=n1231 A2=n1414
XU798 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1091 ZN=n781 A2=n2243
XU1377 NR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1473 A1=n1438 A2=n1374
XU688 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n745 ZN=n472 A2=n604
XU113 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n72 ZN=n30 A2=n650
XU105 CKND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n275 ZN=n643 A2=n2
XU1494 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1664 ZN=n1126 A2=n1142
XU1610 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1663 ZN=n1735 A2=n1681
XU80 CKXOR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<24> A2=rin<56> Z=sin1<24>
XU647 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1750 ZN=n2272
XU1545 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n2203 ZN=n1141 A2=n1697
XU93 CKXOR2D2BWP7T $PINS A1=rin<104> VDD=VDD VSS=VSS A2=rk0<8> Z=n73
XU384 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2207 ZN=n526 A2=n570
XU79 CKXOR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=rk1<25> A2=rin<57> Z=sin1<25>
XU2441 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=rin<125> A2=rk0<29> ZN=n2561
XU85 CKXOR2D2BWP7T $PINS A1=rk1<11> VDD=VDD VSS=VSS A2=rin<43> Z=sin1<11>
XU1279 XNR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<35> A2=rk1<3> ZN=n1439
XU1276 CKXOR2D2BWP7T $PINS A1=rin<32> VDD=VDD VSS=VSS A2=rk1<0> Z=n1462
XU352 CKXOR2D4BWP7T $PINS A1=rin<116> VDD=VDD VSS=VSS A2=rk0<20> Z=n979
XU71 CKXOR2D2BWP7T $PINS A1=rk0<1> VDD=VDD VSS=VSS A2=rin<97> Z=sin0<1>
XU1201 AOI211XD0BWP7T $PINS ZN=n2090 A2=n852 A1=n2045 C=n2732 VDD=VDD B=n851
+ VSS=VSS
XU2481 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2601 I=n1942
XU2334 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2454 I=sout1<25>
XU2502 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2622 I=sout1<10>
XU852 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1918 ZN=n333 A1=n443 A3=n284 A4=n148
XU858 AOI31D0BWP7T $PINS B=n2314 ZN=n332 A1=n2328 A2=n1996 VDD=VDD A3=n294
+ VSS=VSS
XU323 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1922 ZN=n92 A3=n67 A2=n2646
+ A1=n1930
XU1383 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1579 ZN=n1081 A1=n1420 A3=n1045
+ A4=n1044
XU544 ND4D4BWP7T $PINS VSS=VSS VDD=VDD A4=n1289 A3=n137 A2=n2151 ZN=n2081
+ A1=n139
XU1416 AOI21D0BWP7T $PINS VSS=VSS A2=n1054 VDD=VDD A1=n1286 B=n1836 ZN=n1080
XU847 AOI211D2BWP7T $PINS A1=n276 ZN=n1918 A2=n275 B=n882 VDD=VDD C=n425
+ VSS=VSS
XU1950 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1423 A1=n1424 ZN=n1425 A2=n1824
XU1091 AOI21D0BWP7T $PINS VSS=VSS A2=n2718 VDD=VDD A1=n780 B=n1947 ZN=n634
XU1937 NR4D1BWP7T $PINS VSS=VSS A4=n2548 VDD=VDD ZN=n1398 A3=n2160 A2=n1397
+ A1=n1797
XU2383 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2503 I=n489
XU360 CKXOR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=rin<112> A2=rk0<16> Z=n176
XU2549 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2669 I=n619
XU1023 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n2036 ZN=n499 A1=n498 A3=n497
+ A4=n2009
XU1451 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD ZN=n1465 A1=n1076 A2=n1075
XU2469 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2589 I=rk1<14>
XU2543 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2663 I=n1607
XU1400 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1226 A1=n1362 A2=n581
XU2459 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2579 I=rk1<31>
XU1284 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n1347 ZN=n1830 A2=n1037
XU1510 NR2D2P5BWP7T $PINS VSS=VSS A2=n1697 VDD=VDD A1=n1315 ZN=n1163
XU2465 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2585 I=rk0<3>
XU1278 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD ZN=n1414 A1=n1462 A2=n1245
XU2090 AOI22D1BWP7T $PINS ZN=n1783 A1=n1715 A2=n1656 B2=n2776 VDD=VDD B1=n2782
+ VSS=VSS
XU1109 AOI22D2BWP7T $PINS ZN=n690 A1=n1786 A2=n2772 B2=n2777 VDD=VDD B1=n920
+ VSS=VSS
XU2219 AOI22D1BWP7T $PINS ZN=n2127 A1=n1719 A2=n1493 B2=n1723 VDD=VDD B1=n1480
+ VSS=VSS
XU1982 OAI211D2BWP7T $PINS VSS=VSS C=n1271 VDD=VDD A2=n1005 ZN=n2730 A1=n183
+ B=n2147
XU1261 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2085 A1=n1022 A2=n1021 A4=n1019
+ A3=n1020
XU2345 CKND2BWP7T $PINS VSS=VSS I=n2702 VDD=VDD ZN=n2723
XU845 OAI211D1BWP7T $PINS VSS=VSS C=n271 VDD=VDD A2=n1978 ZN=n1942 A1=n273
+ B=n272
XU349 OAI31D1BWP7T $PINS B=n645 A3=n88 ZN=n90 A2=n1923 VDD=VDD A1=n89 VSS=VSS
XU982 OAI31D1BWP7T $PINS B=n645 A3=n438 ZN=n448 A2=n1305 VDD=VDD A1=n440
+ VSS=VSS
XU2084 OAI22D0BWP7T $PINS ZN=n1710 A1=n1709 A2=n1708 B2=n2210 VDD=VDD B1=n1707
+ VSS=VSS
XU1164 OAI211D1BWP7T $PINS VSS=VSS C=n763 VDD=VDD A2=n1961 ZN=n766 A1=n765
+ B=n764
XU851 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n283 A1=n1061 A2=n674 A4=n282 A3=n311
XU2234 OAI211D1BWP7T $PINS VSS=VSS C=n2049 VDD=VDD A2=n2051 ZN=n2053 A1=n2052
+ B=n2050
XU301 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n55 A1=n675 A2=n674 A4=n54 A3=n647
XU983 OAI211D1BWP7T $PINS VSS=VSS C=n654 VDD=VDD A2=n1046 ZN=n446 A1=n622
+ B=n656
XU1832 OAI211D1BWP7T $PINS VSS=VSS C=n1260 VDD=VDD A2=n1808 ZN=n1263 A1=n1262
+ B=n1261
XU604 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1900 A1=n189 A2=n188 A3=n187
XU1896 OAI211D1BWP7T $PINS VSS=VSS C=n1341 VDD=VDD A2=n1708 ZN=n1344 A1=n1343
+ B=n2701
XU282 OAI211D1BWP7T $PINS VSS=VSS C=n42 VDD=VDD A2=n1916 ZN=n45 A1=n44 B=n43
XU1466 IND4D0BWP7T $PINS VSS=VSS A1=n1073 VDD=VDD B1=n1072 B2=n1802 ZN=n1074
+ B3=n1463
XU708 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n594 A2=n226 ZN=n231 A1=n405 A4=n618
XU2014 OAI211D1BWP7T $PINS VSS=VSS C=n1578 VDD=VDD A2=n1580 ZN=n1582 A1=n476
+ B=n1579
XU263 ND3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n885 A1=n32 A2=n437 A3=n31
XU136 OAI211D1BWP7T $PINS VSS=VSS C=n2526 VDD=VDD A2=n57 ZN=n875 A1=n644 B=n863
XU1942 NR4D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n2741 A1=n1600 A2=n1764 A4=n1183
+ A3=n1491
XU761 INVD0BWP7T $PINS ZN=n2118 VSS=VSS VDD=VDD I=n2748
XU714 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n35 A2=n2 A1=n2800
XU676 AO211D0BWP7T $PINS Z=n2799 C=n260 B=n453 A2=n710 VDD=VDD A1=n935 VSS=VSS
XU670 AO211D0BWP7T $PINS Z=n2763 C=n2624 B=n313 A2=n276 VDD=VDD A1=n418 VSS=VSS
XU634 AO211D0BWP7T $PINS Z=n2750 C=n332 B=n331 A2=n1922 VDD=VDD A1=n333 VSS=VSS
XU632 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n2044 ZN=n362 A2=n357
XU628 CKND2D0BWP7T $PINS VSS=VSS A2=n118 VDD=VDD A1=n1446 ZN=n2259
XU627 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1796 I=n2259
XU549 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1740 ZN=n2675 A1=n1755 A3=n1739
+ A4=n1738
XU534 CKND2D0BWP7T $PINS VSS=VSS A2=n1595 VDD=VDD A1=n1732 ZN=n1520
XU531 NR2D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2747 A1=n1156 A2=n1520
XU513 IND4D2BWP7T $PINS VSS=VSS A1=n1636 VDD=VDD B1=n1611 B2=n1186 ZN=n1729
+ B3=n2747
XU475 INR2XD0BWP7T $PINS VSS=VSS A1=n1129 VDD=VDD B1=n1112 ZN=n1508
XU420 NR2D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2746 A1=n1179 A2=n1647
XU406 IND4D1BWP7T $PINS VSS=VSS A1=n1765 VDD=VDD B1=n1700 B2=n1508 B3=n2746
+ ZN=n1620
XU397 AN4D0BWP7T $PINS Z=n2765 A4=n798 A3=n696 A2=n2669 VDD=VDD A1=n1975
+ VSS=VSS
XU392 NR4D0BWP7T $PINS VSS=VSS A4=n308 VDD=VDD ZN=n310 A3=n637 A2=n1060
+ A1=n2792
XU374 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n462 A3=n463 A2=n464 A1=n1099 Z=n2729
XU373 NR2D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n212 A1=n1892 A2=n81
XU368 NR4D1BWP7T $PINS VSS=VSS A4=n210 VDD=VDD ZN=n2745 A3=n313 A2=n652 A1=n435
XU350 CKND2D0BWP7T $PINS VSS=VSS A2=n2745 VDD=VDD A1=n212 ZN=n1913
XU237 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n325 A3=n1994 A2=n327 A1=n1244
+ Z=n2715
XU160 CKND2D0BWP7T $PINS VSS=VSS A2=n2 VDD=VDD A1=n418 ZN=n2285
XU137 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2285 ZN=n426
XU125 NR4D0BWP7T $PINS VSS=VSS A4=n605 VDD=VDD ZN=n2718 A3=n1946 A2=n607
+ A1=n606
XU124 OR4D0BWP7T $PINS VSS=VSS VDD=VDD A4=n993 A3=n1000 A2=n994 A1=n995 Z=n2678
XU109 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n1495 A2=n2157 ZN=n2652 A1=n1497
+ A4=n1596
XU107 AN4D0BWP7T $PINS Z=n2722 A4=n1776 A3=n1775 A2=n1777 VDD=VDD A1=n1778
+ VSS=VSS
XU104 IND4D1BWP7T $PINS VSS=VSS A1=n1635 VDD=VDD B1=n1104 B2=n1319 B3=n1696
+ ZN=n1492
XU84 OA31D0BWP7T $PINS Z=n2751 B=n1922 A3=n1898 A2=n662 A1=n661 VDD=VDD VSS=VSS
XU2352 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2472 I=sout1<26>
XU1081 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD ZN=n804 A1=n712 A2=n592
XU256 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n40 ZN=n1928 A2=n39
XU1792 INR4D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1227 B1=n1226 B2=n1827 B3=n1403
+ ZN=n1229
XU890 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n990 ZN=n347 A1=n524 A3=n2008 A4=n346
XU490 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2037 A1=n2266 A2=n2044
XU54 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<21> I=rin<117>
XU2168 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<64> I=rin<32>
XU27 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<90> I=rin<58>
XU2283 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<7> I=rin<103>
XU20 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<83> I=rin<51>
XU53 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=rout<20> I=rin<116>
XU7 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=rout<70> I=rin<38>
XU21 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=rout<84> I=rin<52>
XU2171 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1617 ZN=n2125 A1=n1581 B2=n1581
+ B1=n1617
XU2290 INVD0BWP7T $PINS ZN=n2788 VSS=VSS VDD=VDD I=n739
XU2289 AO211D0BWP7T $PINS Z=n2787 C=n1411 B=n1412 A2=n1413 VDD=VDD A1=n1414
+ VSS=VSS
XU2252 INVD0BWP7T $PINS ZN=n1424 VSS=VSS VDD=VDD I=n2787
XU2243 AO211D0BWP7T $PINS Z=n2786 C=n1674 B=n1626 A2=n958 VDD=VDD A1=n1628
+ VSS=VSS
XU2235 INVD0BWP7T $PINS ZN=n1629 VSS=VSS VDD=VDD I=n2786
XU2216 AOI21D2BWP7T $PINS VSS=VSS A2=n658 VDD=VDD A1=n2796 B=n1314 ZN=n1650
XU2159 OAI211D2BWP7T $PINS A2=n1126 ZN=n1510 A1=n1680 B=n2273 VDD=VDD C=n1154
+ VSS=VSS
XU2154 AO211D2BWP7T $PINS VSS=VSS A1=n2045 VDD=VDD A2=n379 B=n378 C=n1883
+ Z=n2785
XU2139 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1922 ZN=n219 A3=n322 A2=n1913
+ A1=n218
XU2131 OA31D0BWP7T $PINS Z=n2784 B=n1437 A3=n1438 A2=n1439 A1=n1462 VDD=VDD
+ VSS=VSS
XU2107 INVD1BWP7T $PINS ZN=n1440 VSS=VSS VDD=VDD I=n2784
XU2097 OA31D0BWP7T $PINS Z=n2783 B=n1615 A3=n1616 A2=n2211 A1=n1618 VDD=VDD
+ VSS=VSS
XU2039 INVD0BWP7T $PINS ZN=n1619 VSS=VSS VDD=VDD I=n2783
XU2036 AO211D2BWP7T $PINS VSS=VSS A1=n1465 VDD=VDD A2=n1427 B=n1863 C=n1425
+ Z=n2782
XU1998 INVD2BWP7T $PINS VSS=VSS VDD=VDD ZN=n2617 I=n1874
XU1996 AO211D1BWP7T $PINS VSS=VSS A1=n930 VDD=VDD A2=n635 B=n634 C=n633 Z=n2781
XU1957 INR4D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1195 B1=n100 B2=n1526 B3=n1525
+ ZN=n1528
XU1951 AO211D0BWP7T $PINS Z=n2780 C=n1827 B=n1828 A2=n517 VDD=VDD A1=n1830
+ VSS=VSS
XU1947 INVD0BWP7T $PINS ZN=n2709 VSS=VSS VDD=VDD I=n2780
XU1945 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n2605 I=n1878
XU1892 OR2D0BWP7T $PINS VSS=VSS A1=n2056 VDD=VDD A2=n2054 Z=n2779
XU1878 AOI21D2BWP7T $PINS VSS=VSS A1=n2055 VDD=VDD B=n2053 ZN=n2073 A2=n2779
XU1790 AO211D2BWP7T $PINS Z=n2777 C=n221 B=n222 A2=n223 VDD=VDD A1=n892 VSS=VSS
XU1676 AO211D1BWP7T $PINS VSS=VSS A1=n1490 VDD=VDD A2=n1081 B=n1080 C=n1079
+ Z=n2776
XU1670 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2776 ZN=n1715
XU1639 AN4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n449 A3=n448 A4=n1875 Z=n2774
+ A1=n450
XU1626 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2774 ZN=n1885
XU1625 AN4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n92 A3=n91 A4=n90 Z=n2772 A1=n2136
XU1593 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n920 I=n2772
XU1592 AOI21D2BWP7T $PINS VSS=VSS A1=n767 VDD=VDD B=n766 ZN=n2097 A2=n768
XU1574 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2139 ZN=n2602
XU1542 CKXOR2D0BWP7T $PINS Z=n1023 A2=n1585 A1=n1742 VDD=VDD VSS=VSS
XU1530 CKXOR2D0BWP7T $PINS Z=n1935 A2=n1028 A1=n1813 VDD=VDD VSS=VSS
XU1527 AO22D0BWP7T $PINS Z=n2771 A2=n2412 A1=n1317 B1=n2336 VDD=VDD B2=n1328
+ VSS=VSS
XU1517 IAO22D2BWP7T $PINS B2=n2622 B1=sout1<15> ZN=n1877 A1=n2622 A2=sout1<15>
+ VDD=VDD VSS=VSS
XU1513 CKXOR2D0BWP7T $PINS Z=n2110 A2=n1363 A1=sout1<13> VDD=VDD VSS=VSS
XU1512 CKXOR2D0BWP7T $PINS Z=n917 A2=n916 A1=n1027 VDD=VDD VSS=VSS
XU1470 AOI22D2BWP7T $PINS ZN=n2100 A1=n2777 A2=n2081 B2=n1786 VDD=VDD B1=n1426
+ VSS=VSS
XU1409 CKXOR2D0BWP7T $PINS Z=n2082 A2=n1609 A1=n2781 VDD=VDD VSS=VSS
XU1349 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n1750 A2=n1085 A1=n1618
XU1321 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n530 A2=n99 A1=n124
XU1307 CKAN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n2769 A2=n736 A1=n961
XU1228 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n71 A2=n426 A1=n5
XU1207 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2768 A2=n156 A1=n818
XU1188 CKND2BWP7T $PINS VSS=VSS I=n2768 VDD=VDD ZN=n564
XU1187 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n362 A3=n506 A2=n2037 A1=n347
+ Z=n2767
XU1165 INVD0BWP7T $PINS ZN=n1018 VSS=VSS VDD=VDD I=n2767
XU1142 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1437 A1=n1544 A2=n1551
XU1133 AN4D1BWP7T $PINS Z=n2790 A4=n2241 A3=n1578 A2=n1067 VDD=VDD A1=n1227
+ VSS=VSS
XU1127 AN4D1BWP7T $PINS VSS=VSS A1=n1437 VDD=VDD A2=n1229 A3=n1228 A4=n1242
+ Z=n2794
XU1126 AN4D1BWP7T $PINS VSS=VSS VDD=VDD A2=n127 A3=n2008 A4=n542 Z=n2766
+ A1=n521
XU1122 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2047 I=n2766
XU1106 INVD0BWP7T $PINS ZN=n659 VSS=VSS VDD=VDD I=n2763
XU1056 OA22D0BWP7T $PINS Z=n2761 B1=n1943 A2=n1978 A1=n182 VDD=VDD B2=n1968
+ VSS=VSS
XU1051 INVD0BWP7T $PINS ZN=n633 VSS=VSS VDD=VDD I=n2761
XU1024 AO211D0BWP7T $PINS Z=n2760 C=n704 B=n1959 A2=n705 VDD=VDD A1=n736
+ VSS=VSS
XU1008 INVD0BWP7T $PINS ZN=n706 VSS=VSS VDD=VDD I=n2760
XU1000 OA22D0BWP7T $PINS Z=n2758 B1=n812 A2=n1947 A1=n813 VDD=VDD B2=n1978
+ VSS=VSS
XU989 AN3D1BWP7T $PINS VSS=VSS A1=n1855 VDD=VDD A2=n1857 A3=n2758 Z=n2069
XU964 MOAI22D0BWP7T $PINS A2=n1933 A1=n330 ZN=n331 B1=n2715 VSS=VSS B2=n892
+ VDD=VDD
XU915 OA31D0BWP7T $PINS Z=n2755 B=n1928 A3=n670 A2=n1923 A1=n671 VDD=VDD
+ VSS=VSS
XU914 OA31D0BWP7T $PINS Z=n2754 B=n645 A3=n1937 A2=n647 A1=n149 VDD=VDD VSS=VSS
XU904 OA31D0BWP7T $PINS Z=n2753 B=n892 A3=n679 A2=n1898 A1=n2646 VDD=VDD
+ VSS=VSS
XU876 OR4XD1BWP7T $PINS VSS=VSS A4=n2753 VDD=VDD A3=n2755 A2=n2751 A1=n2754
+ Z=n1025
XU875 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD B2=n1813 B1=n1026 ZN=n912 A1=n1813
+ A2=n1026
XU864 AO211D0BWP7T $PINS Z=n2749 C=n1531 B=n1530 A2=n1756 VDD=VDD A1=n2652
+ VSS=VSS
XU828 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2084 I=n2750
XU786 IAO22D2BWP7T $PINS B2=n1856 B1=n1719 ZN=n2109 A1=n1856 A2=n1719 VDD=VDD
+ VSS=VSS
XU762 AO22D0BWP7T $PINS Z=n2748 A2=n1656 A1=sout1<15> B1=n2782 VDD=VDD B2=n1355
+ VSS=VSS
XU2363 INR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n1201 B1=n1664 A1=n1142
XU2362 OR3D1BWP7T $PINS VSS=VSS A3=n407 VDD=VDD A2=n467 A1=n1664 Z=n2805
XU2359 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1683 A1=n868 A2=n2272
XU2357 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n5 ZN=n275 A2=n418
XU2348 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n2804 A2=n2265 A1=n124
XU2344 INR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n263 B1=n475 A1=n2561
XU2343 CKAN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n119 A2=n2803 A1=n176
XU2341 INVD0BWP7T $PINS ZN=n2803 VSS=VSS VDD=VDD I=n340
XU2340 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n407 A2=n1524 ZN=n1718
XU2339 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n2802 A2=n1375 A1=n439
XU2337 CKAN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n335 A2=n370 A1=n979
XU2336 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n964 A2=n228 A1=n387
XU2335 INVD0BWP7T $PINS ZN=n2800 VSS=VSS VDD=VDD I=n890
XU2330 CKAN2D1BWP7T $PINS VSS=VSS A1=n1413 VDD=VDD A2=n1446 Z=n1287
XU2326 CKAN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n778 A2=n242 A1=n737
XU2325 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1172 ZN=n1662 A2=n1681
XU2318 AOI211XD2BWP7T $PINS A1=n2247 ZN=n143 A2=n530 B=n162 VDD=VDD C=n354
+ VSS=VSS
XU2317 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1126 B=n1626 A1=n1616 ZN=n1734
XU2316 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n499 A3=n500 A2=n501 A1=n1 Z=n2797
XU2315 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n849 I=n2797
XU2313 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2218 ZN=n340 A2=n99
XU2312 OR2D0BWP7T $PINS VSS=VSS A1=n1628 VDD=VDD A2=n1315 Z=n2796
XU2309 AOI21D0BWP7T $PINS VSS=VSS A1=n782 VDD=VDD B=n2804 ZN=n515 A2=n342
XU2308 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD A2=n795 B=n698 A1=n615 ZN=n759
XU2307 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n1001 A3=n361 A2=n1 A1=n362 Z=n2795
XU2306 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n983 I=n2795
XU2305 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1372 I=n2794
XU2304 AO211D0BWP7T $PINS Z=n2793 C=n1226 B=n1251 A2=n1055 VDD=VDD A1=n608
+ VSS=VSS
XU2302 INVD0BWP7T $PINS ZN=n1065 VSS=VSS VDD=VDD I=n2793
XU2301 AO211D0BWP7T $PINS Z=n2792 C=n305 B=n306 A2=n873 VDD=VDD A1=n307 VSS=VSS
XU2300 INVD0BWP7T $PINS ZN=n436 VSS=VSS VDD=VDD I=n2792
XU2296 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1353 I=n2790
XU2295 AOI211D2BWP7T $PINS A1=n469 ZN=n482 A2=n470 B=n468 VDD=VDD C=n809
+ VSS=VSS
XU2294 OR2D0BWP7T $PINS VSS=VSS A1=n1123 VDD=VDD A2=n1705 Z=n2789
XU2293 AOI21D1BWP7T $PINS VSS=VSS A2=n2789 VDD=VDD A1=n1727 B=n1122 ZN=n1999
XU2292 NR2D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n707 A1=n2788 A2=n404
Xicc_clock3 AOI22D1BWP7T $PINS ZN=n8 A1=n1026 A2=n1745 B2=n1767 VDD=VDD
+ B1=n1031 VSS=VSS
Xicc_clock4 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n12 I=n383
Xicc_clock1 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n532 A2=n153 ZN=n1
Xicc_clock2 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4 A1=n1417 A2=n1576 A4=n1416
+ A3=n1535
Xicc_clock5 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n28 I=n2774
Xicc_clock6 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n34 I=n2062
Xicc_clock7 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n36 I=sout0<1>
Xicc_clock8 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n48 I=n2105
Xicc_clock9 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n52 I=sout0<2>
Xicc_place35 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n156 ZN=n664
Xicc_place39 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1663 ZN=n683
Xicc_place53 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n532 ZN=n814
Xicc_place45 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1523 ZN=n747
Xicc_place34 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n2805 ZN=n658
Xicc_place50 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1681 ZN=n792
Xicc_place36 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1616 ZN=n680
Xicc_place52 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1303 ZN=n807
Xicc_place43 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n554 ZN=n731
Xicc_place55 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n125 ZN=n818
Xicc_place49 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n103 ZN=n787
Xicc_place73 CKND2BWP7T $PINS VSS=VSS I=n2804 VDD=VDD ZN=n996
Xicc_place41 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n342 ZN=n685
Xicc_place17 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1273 ZN=n476
Xicc_place11 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1438 ZN=n460
Xicc_place13 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1357 ZN=n465
Xicc_place15 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n745 ZN=n470
Xicc_place16 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1362 ZN=n474
Xicc_place38 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n357 ZN=n682
Xicc_place6 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1439 ZN=n421
Xicc_place4 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1048 ZN=n402
Xicc_place3 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n393 I=rk0<27>
Xicc_place7 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1462 ZN=n427
Xicc_place8 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1347 ZN=n439
Xicc_place1 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1037 ZN=n367
Xicc_place21 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n176 ZN=n512
Xicc_place174 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2131 I=n550
Xicc_place183 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2132 I=n2001
Xicc_place185 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2133 I=n104
Xicc_place195 CKXOR2D2BWP7T $PINS A1=rk1<12> VDD=VDD VSS=VSS A2=rin<44> Z=n2134
Xicc_place196 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2163 I=n1042
Xicc_place200 OAI31D1BWP7T $PINS B=n1756 A3=n1118 ZN=n2135 A2=n1207 VDD=VDD
+ A1=n1335 VSS=VSS
Xicc_place201 AO31D0BWP7T $PINS Z=n2136 B=n1916 A1=n423 A2=n442 VDD=VDD A3=n55
+ VSS=VSS
Xicc_place205 OAI22D0BWP7T $PINS ZN=n2137 A1=n1382 A2=n1836 B2=n459 VDD=VDD
+ B1=n1381 VSS=VSS
Xicc_place210 AOI31D1BWP7T $PINS B=n459 A1=n1573 ZN=n2138 A2=n1572 VDD=VDD
+ A3=n1571 VSS=VSS
Xicc_place214 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n1982 A3=n1983 A2=n1984
+ A1=n1985 Z=n2139
Xicc_place215 NR4D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n2149 A1=n791 A2=n942 A4=n392
+ A3=n781
Xicc_place216 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1882 Z=n2147
Xicc_place221 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2140 I=n2090
Xicc_place222 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2141 I=n589
Xicc_place227 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2142 I=n409
Xicc_place228 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2143 I=n588
Xicc_place229 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2144 I=n549
Xicc_place230 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2145 I=sout0<6>
Xicc_place231 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2146 I=n1710
Xicc_place232 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2148 I=n1847
Xicc_place234 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2151 I=n138
Xicc_place235 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2152 I=n968
Xicc_place236 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2153 I=n805
Xicc_place237 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2154 I=n1384
Xicc_place238 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2155 I=n1711
Xicc_place239 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2156 I=n1114
Xicc_place240 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2157 I=n1496
Xicc_place241 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2158 I=n337
Xicc_place242 INR3D1BWP7T $PINS VSS=VSS VDD=VDD A1=n974 ZN=n2159 B2=n824
+ B1=n992
Xicc_place243 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2160 I=n1396
Xicc_place244 CKBD2BWP7T $PINS VSS=VSS VDD=VDD I=n643 Z=n2161
Xicc_place245 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2162 I=n1308
Xicc_place246 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2164 I=rk1<1>
Xicc_place247 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n515 Z=n2165
Xicc_place202 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2002 I=n1820
Xicc_place203 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2022 I=n2741
Xicc_place204 INVD0BWP7T $PINS ZN=n2025 VSS=VSS VDD=VDD I=n253
Xicc_place206 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2039 I=n93
Xicc_place207 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2040 I=n2517
Xicc_place208 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2060 I=n2625
Xicc_place211 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2066 I=n1346
Xicc_place212 OAI21D2BWP7T $PINS A2=n2804 A1=n566 ZN=n2067 VDD=VDD B=n144
+ VSS=VSS
Xicc_place217 CKBD2BWP7T $PINS VSS=VSS VDD=VDD Z=n2080 I=n1518
Xicc_place218 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1746 Z=n2087
Xicc_place220 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2093 I=n1662
Xicc_place223 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n2104 I=rk1<20>
Xicc_place224 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2129 ZN=n2112
Xicc_place225 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rk0<30> ZN=n2129
Xicc_place226 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n2130 I=n908
Xicc_place168 AOI211XD1BWP7T $PINS ZN=n1829 A2=n1618 A1=n683 C=n2743 VDD=VDD
+ B=n1139 VSS=VSS
Xicc_place177 OAI31D1BWP7T $PINS ZN=n1875 A3=n445 A2=n446 A1=n1889 B=n1928
+ VDD=VDD VSS=VSS
Xicc_place171 OAI31D2BWP7T $PINS ZN=n1847 A3=n545 A2=n546 A1=n547 B=n544
+ VDD=VDD VSS=VSS
Xicc_place179 AOI22D0BWP7T $PINS B1=n544 A2=n169 ZN=n1882 A1=n2055 VDD=VDD
+ B2=n168 VSS=VSS
Xicc_place133 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n1494 I=sout0<3>
Xicc_place167 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n2633 Z=n1826
Xicc_place139 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2730 Z=n1559
Xicc_place142 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n1603 I=n2145
Xicc_place148 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2785 ZN=n1638
Xicc_place161 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2089 Z=n1787
Xicc_place151 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n1682 I=sout0<4>
Xicc_place144 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n1609 I=sout0<0>
Xicc_place163 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2781 ZN=n1813
Xicc_place122 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=sout1<15> ZN=n1355
Xicc_place125 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<8> Z=n1418
Xicc_place141 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n1585 I=n36
Xicc_place134 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2064 Z=n1513
Xicc_place165 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1814 ZN=n1815
Xicc_place150 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2771 ZN=n1677
Xicc_place137 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n48 Z=n1532
Xicc_place156 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=sout0<7> ZN=n1742
Xicc_place160 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n2777 ZN=n1786
Xicc_place140 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2749 ZN=n1581
Xicc_place127 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1434 I=n2085
Xicc_place164 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1814 I=n2086
Xicc_place159 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1785 I=n2140
Xicc_place149 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2782 ZN=n1656
Xicc_place132 CKND1BWP7T $PINS VSS=VSS VDD=VDD I=n1480 ZN=n1493
Xicc_place131 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1914 ZN=n1471
Xicc_place146 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1864 Z=n1627
Xicc_place119 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<9> Z=n1333
Xicc_place128 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n1452 I=n52
Xicc_place136 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2403 Z=n1519
Xicc_place126 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2081 ZN=n1426
Xicc_place123 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1880 Z=n1363
Xicc_place154 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1719 I=n1999
Xicc_place143 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1606 I=n1939
Xicc_place117 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<30> Z=n1317
Xicc_place116 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2799 ZN=n1316
Xicc_place109 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n85 ZN=n1244
Xicc_place79 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n420 ZN=n1053
Xicc_place66 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1195 ZN=n922
Xicc_place219 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1445 Z=n2088
Xicc_place89 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n722 ZN=n1099
Xicc_place81 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n300 ZN=n1061
Xicc_place87 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n61 ZN=n1095
Xicc_place76 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n873 ZN=n1046
Xicc_place69 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n935 I=n795
Xicc_place94 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n57 ZN=n1108
Xicc_place58 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n128 ZN=n869
Xicc_place30 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n622 I=n185
Xicc_place72 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1735 ZN=n960
Xicc_place64 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n773 ZN=n915
Xicc_place63 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n985 ZN=n914
Xicc_place51 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n417 ZN=n793
Xicc_place91 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n245 ZN=n1101
Xicc_place37 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1910 ZN=n681
Xicc_place90 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1100 I=n250
Xicc_place75 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1153 ZN=n1041
Xicc_place92 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n737 ZN=n1102
Xicc_place18 INVD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n1446 ZN=n485
Xicc_place67 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1671 ZN=n923
Xicc_place61 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1126 ZN=n910
Xicc_place26 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n276 ZN=n567
Xicc_place102 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n71 ZN=n1182
Xicc_place71 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1698 ZN=n958
Xicc_place83 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n705 ZN=n1083
Xicc_place32 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n2802 ZN=n638
Xicc_place56 INVD4BWP7T $PINS VDD=VDD VSS=VSS I=n566 ZN=n859
Xicc_place48 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n335 ZN=n782
Xicc_place19 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1374 ZN=n495
Xicc_place29 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1563 ZN=n608
Xicc_place25 CKND0BWP7T $PINS VDD=VDD VSS=VSS I=n1216 ZN=n541
Xicc_place28 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1217 ZN=n581
Xicc_place42 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n2044 ZN=n688
Xicc_place23 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1562 ZN=n517
Xicc_place2 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n385 I=rk1<2>
Xicc_place5 CKND2BWP7T $PINS VSS=VSS I=n1618 VDD=VDD ZN=n407
Xicc_place9 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n441 I=n1116
Xicc_place10 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n459 I=n1465
Xicc_place12 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n461 I=n5
Xicc_place14 INVD0BWP7T $PINS ZN=n467 VSS=VSS VDD=VDD I=n1087
Xicc_place20 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n511 I=n979
Xicc_place22 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n516 I=n418
Xicc_place24 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n525 I=n370
Xicc_place27 INVD0BWP7T $PINS ZN=n580 VSS=VSS VDD=VDD I=n122
Xicc_place31 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n623 I=n526
Xicc_place33 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n651 I=n112
Xicc_place40 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n684 I=n1071
Xicc_place44 CKND2BWP7T $PINS VSS=VSS I=n38 VDD=VDD ZN=n743
Xicc_place46 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n756 I=n355
Xicc_place47 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n774 I=n275
Xicc_place57 CKND2BWP7T $PINS VSS=VSS I=n1691 VDD=VDD ZN=n868
Xicc_place59 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n889 I=n1413
Xicc_place60 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n896 I=n80
Xicc_place65 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n921 I=n620
Xicc_place68 INVD0BWP7T $PINS ZN=n924 VSS=VSS VDD=VDD I=n161
Xicc_place70 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n936 I=n1554
Xicc_place74 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1821 Z=n998
Xicc_place77 CKND4BWP7T $PINS VSS=VSS VDD=VDD I=n746 ZN=n1047
Xicc_place78 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1050 I=n1125
Xicc_place80 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1060 I=n672
Xicc_place82 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1082 I=n204
Xicc_place84 INVD0BWP7T $PINS ZN=n1089 VSS=VSS VDD=VDD I=n313
Xicc_place85 CKND3BWP7T $PINS VSS=VSS VDD=VDD ZN=n1091 I=n387
Xicc_place86 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1092 I=n507
Xicc_place88 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1098 I=n75
Xicc_place93 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1103 I=n649
Xicc_place95 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1119 I=n615
Xicc_place96 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1132 I=n210
Xicc_place97 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1137 I=n237
Xicc_place98 INVD0BWP7T $PINS ZN=n1143 VSS=VSS VDD=VDD I=n858
Xicc_place99 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1148 I=n900
Xicc_place100 INVD0BWP7T $PINS ZN=n1158 VSS=VSS VDD=VDD I=n1701
Xicc_place101 INVD0BWP7T $PINS ZN=n1162 VSS=VSS VDD=VDD I=n472
Xicc_place103 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1049 Z=n1193
Xicc_place104 INVD0BWP7T $PINS ZN=n1206 VSS=VSS VDD=VDD I=n1339
Xicc_place105 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1208 I=n749
Xicc_place106 INVD0BWP7T $PINS ZN=n1218 VSS=VSS VDD=VDD I=n755
Xicc_place107 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1230 I=n729
Xicc_place108 INVD0BWP7T $PINS ZN=n1233 VSS=VSS VDD=VDD I=n1492
Xicc_place110 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1267 I=n953
Xicc_place111 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1270 I=n464
Xicc_place112 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1271 I=n181
Xicc_place113 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1288 I=n1964
Xicc_place114 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n136 Z=n1289
Xicc_place115 INVD0BWP7T $PINS ZN=n1305 VSS=VSS VDD=VDD I=n206
Xicc_place118 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1328 I=n1317
Xicc_place120 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1342 I=n1333
Xicc_place124 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1394 I=n1911
Xicc_place129 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1461 I=n1452
Xicc_place130 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1468 I=sout0<5>
Xicc_place135 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1514 I=n1513
Xicc_place138 INVD0BWP7T $PINS ZN=n1543 VSS=VSS VDD=VDD I=n1856
Xicc_place147 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1632 I=n1627
Xicc_place152 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1685 I=n1682
Xicc_place153 INVD0BWP7T $PINS ZN=n1706 VSS=VSS VDD=VDD I=sout1<28>
Xicc_place155 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1723 I=n1719
Xicc_place157 INVD0BWP7T $PINS ZN=n1745 VSS=VSS VDD=VDD I=n1031
Xicc_place158 INVD0BWP7T $PINS ZN=n1767 VSS=VSS VDD=VDD I=n1026
Xicc_place162 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1790 I=n1787
Xicc_place166 INVD0BWP7T $PINS ZN=n1818 VSS=VSS VDD=VDD I=n2113
Xicc_place62 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n2769 ZN=n911
Xicc_place145 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=sout1<24> Z=n1617
Xicc_place121 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1348 I=sout1<13>
Xicc_place169 AO32D0BWP7T $PINS Z=n1832 B2=n848 B1=n1005 A1=n849 A2=n848
+ VDD=VDD A3=n82 VSS=VSS
Xicc_place170 NR4D1BWP7T $PINS VSS=VSS A4=n204 VDD=VDD ZN=n1839 A3=n899 A2=n278
+ A1=n81
Xicc_place172 AO21D0BWP7T $PINS Z=n1855 B=n1961 A1=n780 VDD=VDD A2=n779 VSS=VSS
Xicc_place173 AO31D1BWP7T $PINS VSS=VSS A3=n788 VDD=VDD A2=n949 A1=n789 B=n1968
+ Z=n1857
Xicc_place175 AOI31D1BWP7T $PINS B=n1808 A1=n1405 ZN=n1863 A2=n1798 VDD=VDD
+ A3=n1404 VSS=VSS
Xicc_place176 OR4D1BWP7T $PINS VSS=VSS VDD=VDD A4=n1299 A3=n1300 A2=n1301
+ A1=n1302 Z=n1874
Xicc_place178 OR4XD1BWP7T $PINS VSS=VSS VDD=VDD A4=n1212 A3=n1213 A2=n1214
+ A1=n1215 Z=n1878
Xicc_place181 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n909 Z=n1886
Xicc_place182 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n1884 I=n1783
Xicc_place184 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1893 I=n1488
Xicc_place186 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1902 I=n2406
Xicc_place187 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1911 I=sout1<27>
Xicc_place188 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n1914 I=sout1<29>
Xicc_place189 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1937 I=n646
Xicc_place190 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1943 I=n631
Xicc_place191 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1956 I=n1851
Xicc_place193 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1986 I=n1165
Xicc_place194 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1991 I=n1489
Xicc_place197 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n1994 I=n326
Xicc_place198 ND4D1BWP7T $PINS VSS=VSS VDD=VDD A3=n320 A2=n434 ZN=n1995 A1=n321
+ A4=n663
Xicc_place199 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n1996 I=n295
Xicc_clock10 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n56 I=n15
Xicc_clock11 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n62 I=n2137
Xicc_clock12 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n64 I=n451
Xicc_clock13 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n82 I=n847
Xicc_clock14 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n84 I=n1250
Xicc_clock15 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n93 I=n1919
Xicc_clock16 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n94 I=n1064
Xicc_clock17 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n95 I=n1329
Xicc_clock18 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n100 I=n1527
Xicc_clock19 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n111 I=n643
Xicc_clock20 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n112 I=rk0<13>
Xicc_clock21 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n126 ZN=n118
Xicc_clock22 INVD0BWP7T $PINS ZN=n126 VSS=VSS VDD=VDD I=n1246
Xicc_clock23 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n134 I=rk0<26>
Xicc_clock24 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n140 I=rk1<4>
.ENDS

.SUBCKT clefia_128 c<127> c<126> c<125> c<124> c<123> c<122> c<121> c<120>
+ c<119> c<118> c<117> c<116> c<115> c<114> c<113> c<112> c<111> c<110> c<109>
+ c<108> c<107> c<106> c<105> c<104> c<103> c<102> c<101> c<100> c<99> c<98>
+ c<97> c<96> c<95> c<94> c<93> c<92> c<91> c<90> c<89> c<88> c<87> c<86> c<85>
+ c<84> c<83> c<82> c<81> c<80> c<79> c<78> c<77> c<76> c<75> c<74> c<73> c<72>
+ c<71> c<70> c<69> c<68> c<67> c<66> c<65> c<64> c<63> c<62> c<61> c<60> c<59>
+ c<58> c<57> c<56> c<55> c<54> c<53> c<52> c<51> c<50> c<49> c<48> c<47> c<46>
+ c<45> c<44> c<43> c<42> c<41> c<40> c<39> c<38> c<37> c<36> c<35> c<34> c<33>
+ c<32> c<31> c<30> c<29> c<28> c<27> c<26> c<25> c<24> c<23> c<22> c<21> c<20>
+ c<19> c<18> c<17> c<16> c<15> c<14> c<13> c<12> c<11> c<10> c<9> c<8> c<7>
+ c<6> c<5> c<4> c<3> c<2> c<1> c<0> done clk reset_n k<127> k<126> k<125>
+ k<124> k<123> k<122> k<121> k<120> k<119> k<118> k<117> k<116> k<115> k<114>
+ k<113> k<112> k<111> k<110> k<109> k<108> k<107> k<106> k<105> k<104> k<103>
+ k<102> k<101> k<100> k<99> k<98> k<97> k<96> k<95> k<94> k<93> k<92> k<91>
+ k<90> k<89> k<88> k<87> k<86> k<85> k<84> k<83> k<82> k<81> k<80> k<79> k<78>
+ k<77> k<76> k<75> k<74> k<73> k<72> k<71> k<70> k<69> k<68> k<67> k<66> k<65>
+ k<64> k<63> k<62> k<61> k<60> k<59> k<58> k<57> k<56> k<55> k<54> k<53> k<52>
+ k<51> k<50> k<49> k<48> k<47> k<46> k<45> k<44> k<43> k<42> k<41> k<40> k<39>
+ k<38> k<37> k<36> k<35> k<34> k<33> k<32> k<31> k<30> k<29> k<28> k<27> k<26>
+ k<25> k<24> k<23> k<22> k<21> k<20> k<19> k<18> k<17> k<16> k<15> k<14> k<13>
+ k<12> k<11> k<10> k<9> k<8> k<7> k<6> k<5> k<4> k<3> k<2> k<1> k<0> p<127>
+ p<126> p<125> p<124> p<123> p<122> p<121> p<120> p<119> p<118> p<117> p<116>
+ p<115> p<114> p<113> p<112> p<111> p<110> p<109> p<108> p<107> p<106> p<105>
+ p<104> p<103> p<102> p<101> p<100> p<99> p<98> p<97> p<96> p<95> p<94> p<93>
+ p<92> p<91> p<90> p<89> p<88> p<87> p<86> p<85> p<84> p<83> p<82> p<81> p<80>
+ p<79> p<78> p<77> p<76> p<75> p<74> p<73> p<72> p<71> p<70> p<69> p<68> p<67>
+ p<66> p<65> p<64> p<63> p<62> p<61> p<60> p<59> p<58> p<57> p<56> p<55> p<54>
+ p<53> p<52> p<51> p<50> p<49> p<48> p<47> p<46> p<45> p<44> p<43> p<42> p<41>
+ p<40> p<39> p<38> p<37> p<36> p<35> p<34> p<33> p<32> p<31> p<30> p<29> p<28>
+ p<27> p<26> p<25> p<24> p<23> p<22> p<21> p<20> p<19> p<18> p<17> p<16> p<15>
+ p<14> p<13> p<12> p<11> p<10> p<9> p<8> p<7> p<6> p<5> p<4> p<3> p<2> p<1>
+ p<0> start VDD VSS
Xu_clefia_round clefia_round $PINS rout<127>=rout<127> rout<126>=rout<126>
+ rout<125>=rout<125> rout<124>=rout<124> rout<123>=rout<123> rout<122>=rout<122>
+ rout<121>=rout<121> rout<120>=rout<120> rout<119>=rout<119> rout<118>=rout<118>
+ rout<117>=rout<117> rout<116>=rout<116> rout<115>=rout<115> rout<114>=rout<114>
+ rout<113>=rout<113> rout<112>=rout<112> rout<111>=rout<111> rout<110>=rout<110>
+ rout<109>=rout<109> rout<108>=rout<108> rout<107>=rout<107> rout<106>=rout<106>
+ rout<105>=rout<105> rout<104>=rout<104> rout<103>=rout<103> rout<102>=rout<102>
+ rout<101>=rout<101> rout<100>=rout<100> rout<99>=rout<99> rout<98>=rout<98>
+ rout<97>=rout<97> rout<96>=rout<96> rout<95>=SYNOPSYS_UNCONNECTED_1
+ rout<94>=SYNOPSYS_UNCONNECTED_2 rout<93>=SYNOPSYS_UNCONNECTED_3
+ rout<92>=SYNOPSYS_UNCONNECTED_4 rout<91>=SYNOPSYS_UNCONNECTED_5
+ rout<90>=rout<90> rout<89>=SYNOPSYS_UNCONNECTED_6
+ rout<88>=SYNOPSYS_UNCONNECTED_7 rout<87>=SYNOPSYS_UNCONNECTED_8
+ rout<86>=SYNOPSYS_UNCONNECTED_9 rout<85>=SYNOPSYS_UNCONNECTED_10
+ rout<84>=rout<84> rout<83>=rout<83> rout<82>=SYNOPSYS_UNCONNECTED_11
+ rout<81>=SYNOPSYS_UNCONNECTED_12 rout<80>=SYNOPSYS_UNCONNECTED_13
+ rout<79>=SYNOPSYS_UNCONNECTED_14 rout<78>=SYNOPSYS_UNCONNECTED_15
+ rout<77>=SYNOPSYS_UNCONNECTED_16 rout<76>=SYNOPSYS_UNCONNECTED_17
+ rout<75>=SYNOPSYS_UNCONNECTED_18 rout<74>=SYNOPSYS_UNCONNECTED_19
+ rout<73>=SYNOPSYS_UNCONNECTED_20 rout<72>=SYNOPSYS_UNCONNECTED_21
+ rout<71>=SYNOPSYS_UNCONNECTED_22 rout<70>=rout<70>
+ rout<69>=SYNOPSYS_UNCONNECTED_23 rout<68>=SYNOPSYS_UNCONNECTED_24
+ rout<67>=SYNOPSYS_UNCONNECTED_25 rout<66>=SYNOPSYS_UNCONNECTED_26
+ rout<65>=SYNOPSYS_UNCONNECTED_27 rout<64>=n2479 rout<63>=rout<63>
+ rout<62>=rout<62> rout<61>=rout<61> rout<60>=rout<60> rout<59>=rout<59>
+ rout<58>=rout<58> rout<57>=rout<57> rout<56>=rout<56> rout<55>=rout<55>
+ rout<54>=rout<54> rout<53>=rout<53> rout<52>=rout<52> rout<51>=rout<51>
+ rout<50>=rout<50> rout<49>=rout<49> rout<48>=rout<48> rout<47>=rout<47>
+ rout<46>=rout<46> rout<45>=rout<45> rout<44>=rout<44> rout<43>=rout<43>
+ rout<42>=rout<42> rout<41>=rout<41> rout<40>=rout<40> rout<39>=rout<39>
+ rout<38>=rout<38> rout<37>=rout<37> rout<36>=rout<36> rout<35>=rout<35>
+ rout<34>=rout<34> rout<33>=rout<33> rout<32>=rout<32>
+ rout<31>=SYNOPSYS_UNCONNECTED_28 rout<30>=SYNOPSYS_UNCONNECTED_29
+ rout<29>=SYNOPSYS_UNCONNECTED_30 rout<28>=SYNOPSYS_UNCONNECTED_31
+ rout<27>=SYNOPSYS_UNCONNECTED_32 rout<26>=SYNOPSYS_UNCONNECTED_33
+ rout<25>=SYNOPSYS_UNCONNECTED_34 rout<24>=SYNOPSYS_UNCONNECTED_35
+ rout<23>=SYNOPSYS_UNCONNECTED_36 rout<22>=SYNOPSYS_UNCONNECTED_37
+ rout<21>=rout<21> rout<20>=rout<20> rout<19>=SYNOPSYS_UNCONNECTED_38
+ rout<18>=SYNOPSYS_UNCONNECTED_39 rout<17>=SYNOPSYS_UNCONNECTED_40
+ rout<16>=SYNOPSYS_UNCONNECTED_41 rout<15>=SYNOPSYS_UNCONNECTED_42
+ rout<14>=SYNOPSYS_UNCONNECTED_43 rout<13>=SYNOPSYS_UNCONNECTED_44
+ rout<12>=SYNOPSYS_UNCONNECTED_45 rout<11>=SYNOPSYS_UNCONNECTED_46
+ rout<10>=SYNOPSYS_UNCONNECTED_47 rout<9>=SYNOPSYS_UNCONNECTED_48
+ rout<8>=SYNOPSYS_UNCONNECTED_49 rout<7>=n2453 rout<6>=rout<6>
+ rout<5>=SYNOPSYS_UNCONNECTED_50 rout<4>=SYNOPSYS_UNCONNECTED_51
+ rout<3>=SYNOPSYS_UNCONNECTED_52 rout<2>=SYNOPSYS_UNCONNECTED_53
+ rout<1>=SYNOPSYS_UNCONNECTED_54 rout<0>=SYNOPSYS_UNCONNECTED_55 rin<127>=n3919
+ rin<126>=n3943 rin<125>=rin<125> rin<124>=rin<124> rin<123>=n3921
+ rin<122>=n3923 rin<121>=n3925 rin<120>=rin<120> rin<119>=rin<119>
+ rin<118>=rin<118> rin<117>=rin<117> rin<116>=rin<116> rin<115>=n3931
+ rin<114>=n3933 rin<113>=n3964 rin<112>=n3934 rin<111>=rin<111> rin<110>=n3938
+ rin<109>=n3963 rin<108>=n3939 rin<107>=n3958 rin<106>=n3940 rin<105>=n3953
+ rin<104>=n3941 rin<103>=rin<103> rin<102>=rin<102> rin<101>=n3884
+ rin<100>=n3885 rin<99>=n3886 rin<98>=n3887 rin<97>=n3888 rin<96>=n3949
+ rin<95>=rin<95> rin<94>=rin<94> rin<93>=rin<93> rin<92>=rin<92> rin<91>=rin<91>
+ rin<90>=rin<90> rin<89>=rin<89> rin<88>=rin<88> rin<87>=rin<87> rin<86>=rin<86>
+ rin<85>=rin<85> rin<84>=rin<84> rin<83>=rin<83> rin<82>=rin<82> rin<81>=rin<81>
+ rin<80>=rin<80> rin<79>=rin<79> rin<78>=rin<78> rin<77>=rin<77> rin<76>=rin<76>
+ rin<75>=rin<75> rin<74>=rin<74> rin<73>=rin<73> rin<72>=rin<72> rin<71>=rin<71>
+ rin<70>=rin<70> rin<69>=rin<69> rin<68>=rin<68> rin<67>=rin<67> rin<66>=rin<66>
+ rin<65>=rin<65> rin<64>=rin<64> rin<63>=rin<63> rin<62>=n3945 rin<61>=rin<61>
+ rin<60>=rin<60> rin<59>=n3895 rin<58>=rin<58> rin<57>=rin<57> rin<56>=n3899
+ rin<55>=n3901 rin<54>=rin<54> rin<53>=n3905 rin<52>=rin<52> rin<51>=rin<51>
+ rin<50>=n3907 rin<49>=rin<49> rin<48>=rin<48> rin<47>=n3947 rin<46>=n3910
+ rin<45>=n3956 rin<44>=rin<44> rin<43>=n3913 rin<42>=rin<42> rin<41>=rin<41>
+ rin<40>=rin<40> rin<39>=n3914 rin<38>=rin<38> rin<37>=n3915 rin<36>=n3916
+ rin<35>=n3917 rin<34>=n3918 rin<33>=n3868 rin<32>=rin<32> rin<31>=rin<31>
+ rin<30>=rin<30> rin<29>=rin<29> rin<28>=rin<28> rin<27>=rin<27> rin<26>=rin<26>
+ rin<25>=rin<25> rin<24>=rin<24> rin<23>=rin<23> rin<22>=rin<22> rin<21>=rin<21>
+ rin<20>=rin<20> rin<19>=rin<19> rin<18>=rin<18> rin<17>=rin<17> rin<16>=rin<16>
+ rin<15>=rin<15> rin<14>=rin<14> rin<13>=rin<13> rin<12>=rin<12> rin<11>=rin<11>
+ rin<10>=rin<10> rin<9>=rin<9> rin<8>=rin<8> rin<7>=rin<7> rin<6>=rin<6>
+ rin<5>=rin<5> rin<4>=rin<4> rin<3>=rin<3> rin<2>=rin<2> rin<1>=rin<1>
+ rin<0>=rin<0> rk0<31>=rk0<31> rk0<30>=rk0<30> rk0<29>=rk0<29> rk0<28>=rk0<28>
+ rk0<27>=rk0<27> rk0<26>=rk0<26> rk0<25>=rk0<25> rk0<24>=rk0<24> rk0<23>=rk0<23>
+ rk0<22>=rk0<22> rk0<21>=rk0<21> rk0<20>=rk0<20> rk0<19>=rk0<19> rk0<18>=rk0<18>
+ rk0<17>=rk0<17> rk0<16>=rk0<16> rk0<15>=rk0<15> rk0<14>=rk0<14> rk0<13>=rk0<13>
+ rk0<12>=rk0<12> rk0<11>=rk0<11> rk0<10>=rk0<10> rk0<9>=rk0<9> rk0<8>=rk0<8>
+ rk0<7>=rk0<7> rk0<6>=rk0<6> rk0<5>=rk0<5> rk0<4>=rk0<4> rk0<3>=rk0<3>
+ rk0<2>=rk0<2> rk0<1>=rk0<1> rk0<0>=rk0<0> rk1<31>=rk1<31> rk1<30>=rk1<30>
+ rk1<29>=rk1<29> rk1<28>=rk1<28> rk1<27>=rk1<27> rk1<26>=rk1<26> rk1<25>=rk1<25>
+ rk1<24>=rk1<24> rk1<23>=rk1<23> rk1<22>=rk1<22> rk1<21>=rk1<21> rk1<20>=rk1<20>
+ rk1<19>=rk1<19> rk1<18>=rk1<18> rk1<17>=rk1<17> rk1<16>=rk1<16> rk1<15>=rk1<15>
+ rk1<14>=rk1<14> rk1<13>=rk1<13> rk1<12>=rk1<12> rk1<11>=rk1<11> rk1<10>=rk1<10>
+ rk1<9>=rk1<9> rk1<8>=rk1<8> rk1<7>=rk1<7> rk1<6>=rk1<6> rk1<5>=rk1<5>
+ rk1<4>=rk1<4> rk1<3>=rk1<3> rk1<2>=n3622 rk1<1>=rk1<1> rk1<0>=rk1<0> VDD=VDD
+ VSS=VSS
Xicc_route_opt1554 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4465 I=rout<57>
Xicc_route_opt1553 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2402 Z=n4464
Xicc_route_opt1552 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<37> Z=n4463
Xicc_route_opt1551 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2388 Z=n4462
XU2376 AOI22D1BWP7T $PINS B1=n3972 A2=n1655 ZN=n1662 A1=n3983 VDD=VDD B2=n1657
+ VSS=VSS
Xicc_place1817 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3972 I=n2770
XU2030 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3852 ZN=n1552 A2=n1428
XU1869 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=round<2> ZN=n1428 A2=n1759
XU2489 AOI21D0BWP7T $PINS VSS=VSS A2=n4106 VDD=VDD A1=n3830 B=n1775 ZN=n1777
Xicc_place1706 INVD8BWP7T $PINS VSS=VSS I=n3856 VDD=VDD ZN=n3861
Xicc_place1894 BUFFD10BWP7T $PINS VSS=VSS VDD=VDD Z=n4049 I=n3679
Xicc_place1895 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4050 I=n3679
XU1838 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n3989 ZN=n3679 A2=n4015
Xicc_place1834 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n3989 I=n3683
XU1559 AO221D0BWP7T $PINS Z=n3519 C=n4002 B1=n1191 A2=n4465 A1=n4335 VDD=VDD
+ B2=n4115 VSS=VSS
XU2859 MAOI22D1BWP7T $PINS A2=p<88> ZN=n2139 A1=n3838 B2=p<88> VDD=VDD B1=n3838
+ VSS=VSS
Xrin_reg_102_ DFCNQD2BWP7T $PINS D=N199 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<102>
Xrin_reg_101_ DFCNQD1BWP7T $PINS D=N198 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<101>
Xrin_reg_100_ DFCNQD1BWP7T $PINS D=N197 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<100>
Xrin_reg_99_ DFCNQD1BWP7T $PINS D=N196 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<99>
Xrin_reg_98_ DFCNQD1BWP7T $PINS D=N195 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<98>
Xrin_reg_97_ DFCNQD1BWP7T $PINS D=N194 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<97>
Xrin_reg_95_ DFCNQD1BWP7T $PINS D=N192 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<95>
Xrin_reg_94_ DFCNQD1BWP7T $PINS D=N191 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<94>
Xrin_reg_93_ DFCNQD1BWP7T $PINS D=N190 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<93>
Xrin_reg_92_ DFCNQD1BWP7T $PINS D=N189 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<92>
Xrin_reg_91_ DFCNQD1BWP7T $PINS D=N188 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<91>
Xrin_reg_90_ DFCNQD1BWP7T $PINS D=N187 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<90>
Xrin_reg_89_ DFCNQD1BWP7T $PINS D=N186 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<89>
Xrin_reg_88_ DFCNQD1BWP7T $PINS D=N185 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<88>
Xrin_reg_87_ DFCNQD1BWP7T $PINS D=N184 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<87>
Xrin_reg_86_ DFCNQD1BWP7T $PINS D=N183 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<86>
Xrin_reg_85_ DFCNQD1BWP7T $PINS D=N182 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<85>
Xrin_reg_84_ DFCNQD1BWP7T $PINS D=N181 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<84>
Xrin_reg_83_ DFCNQD1BWP7T $PINS D=N180 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<83>
Xrin_reg_82_ DFCNQD1BWP7T $PINS D=N179 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<82>
Xrin_reg_81_ DFCNQD1BWP7T $PINS D=n4231 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<81>
Xrin_reg_80_ DFCNQD1BWP7T $PINS D=N177 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<80>
Xrin_reg_79_ DFCNQD1BWP7T $PINS D=N176 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<79>
Xrin_reg_78_ DFCNQD1BWP7T $PINS D=N175 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<78>
Xrin_reg_77_ DFCNQD1BWP7T $PINS D=N174 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<77>
Xrin_reg_76_ DFCNQD1BWP7T $PINS D=N173 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<76>
Xrin_reg_75_ DFCNQD1BWP7T $PINS D=N172 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<75>
Xrin_reg_74_ DFCNQD1BWP7T $PINS D=N171 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<74>
Xrin_reg_73_ DFCNQD1BWP7T $PINS D=N170 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<73>
Xrin_reg_72_ DFCNQD1BWP7T $PINS D=N169 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<72>
Xrin_reg_71_ DFCNQD1BWP7T $PINS D=N168 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<71>
Xrin_reg_70_ DFCNQD1BWP7T $PINS D=N167 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<70>
Xrin_reg_69_ DFCNQD1BWP7T $PINS D=N166 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<69>
Xrin_reg_68_ DFCNQD1BWP7T $PINS D=N165 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<68>
Xrin_reg_67_ DFCNQD1BWP7T $PINS D=N164 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<67>
Xrin_reg_66_ DFCNQD1BWP7T $PINS D=N163 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<66>
Xrin_reg_65_ DFCNQD1BWP7T $PINS D=N162 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<65>
Xrin_reg_64_ DFCNQD1BWP7T $PINS D=N161 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<64>
Xrin_reg_63_ DFCNQD1BWP7T $PINS D=N160 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<63>
Xrin_reg_61_ DFCNQD2BWP7T $PINS D=N158 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<61>
Xrin_reg_60_ DFCNQD1BWP7T $PINS D=N157 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<60>
Xrin_reg_59_ DFCNQD1BWP7T $PINS D=N156 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<59>
Xrin_reg_58_ DFCNQD1BWP7T $PINS D=N155 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<58>
Xrin_reg_57_ DFCNQD1BWP7T $PINS D=N154 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<57>
Xrin_reg_56_ DFCNQD1BWP7T $PINS D=N153 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<56>
Xrin_reg_55_ DFCNQD1BWP7T $PINS D=N152 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<55>
Xrin_reg_54_ DFCNQD1BWP7T $PINS D=N151 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<54>
Xrin_reg_53_ DFCNQD1BWP7T $PINS D=N150 CDN=n3850 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<53>
Xrin_reg_52_ DFCNQD1BWP7T $PINS D=N149 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<52>
Xrin_reg_51_ DFCNQD1BWP7T $PINS D=N148 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<51>
Xrin_reg_50_ DFCNQD1BWP7T $PINS D=N147 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<50>
Xrin_reg_48_ DFCNQD1BWP7T $PINS D=N145 CDN=n3844 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<48>
Xrin_reg_46_ DFCNQD1BWP7T $PINS D=N143 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<46>
Xrin_reg_44_ DFCNQD1BWP7T $PINS D=N141 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<44>
Xrin_reg_43_ DFCNQD1BWP7T $PINS D=N140 CDN=n3850 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<43>
Xrin_reg_39_ DFCNQD1BWP7T $PINS D=N136 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<39>
Xrin_reg_38_ DFCNQD1BWP7T $PINS D=N135 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<38>
Xrin_reg_37_ DFCNQD1BWP7T $PINS D=N134 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<37>
Xrin_reg_36_ DFCNQD1BWP7T $PINS D=N133 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<36>
Xrin_reg_35_ DFCNQD1BWP7T $PINS D=N132 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<35>
Xrin_reg_34_ DFCNQD1BWP7T $PINS D=N131 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<34>
Xrin_reg_32_ DFCNQD1BWP7T $PINS D=N129 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<32>
Xrin_reg_31_ DFCNQD1BWP7T $PINS D=N128 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<31>
Xrin_reg_30_ DFCNQD1BWP7T $PINS D=N127 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<30>
Xrin_reg_29_ DFCNQD1BWP7T $PINS D=N126 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<29>
Xrin_reg_28_ DFCNQD1BWP7T $PINS D=n4100 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<28>
Xrin_reg_27_ DFCNQD1BWP7T $PINS D=N124 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<27>
Xrin_reg_26_ DFCNQD1BWP7T $PINS D=N123 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<26>
Xrin_reg_25_ DFCNQD1BWP7T $PINS D=n4358 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<25>
Xrin_reg_24_ DFCNQD1BWP7T $PINS D=N121 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<24>
Xrin_reg_23_ DFCNQD1BWP7T $PINS D=n4359 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<23>
Xrin_reg_22_ DFCNQD1BWP7T $PINS D=N119 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<22>
Xrin_reg_21_ DFCNQD1BWP7T $PINS D=N118 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<21>
Xrin_reg_20_ DFCNQD1BWP7T $PINS D=N117 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<20>
Xrin_reg_19_ DFCNQD1BWP7T $PINS D=N116 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<19>
Xrin_reg_18_ DFCNQD1BWP7T $PINS D=N115 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<18>
Xrin_reg_17_ DFCNQD1BWP7T $PINS D=N114 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<17>
Xrin_reg_16_ DFCNQD1BWP7T $PINS D=N113 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<16>
Xrin_reg_15_ DFCNQD1BWP7T $PINS D=N112 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<15>
Xrin_reg_14_ DFCNQD1BWP7T $PINS D=N111 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<14>
Xrin_reg_13_ DFCNQD1BWP7T $PINS D=N110 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<13>
Xrin_reg_12_ DFCNQD1BWP7T $PINS D=N109 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<12>
Xrin_reg_11_ DFCNQD1BWP7T $PINS D=N108 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<11>
Xrin_reg_10_ DFCNQD1BWP7T $PINS D=n4101 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<10>
Xrin_reg_9_ DFCNQD1BWP7T $PINS D=N106 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<9>
Xrin_reg_8_ DFCNQD1BWP7T $PINS D=N105 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<8>
Xrin_reg_7_ DFCNQD1BWP7T $PINS D=N104 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<7>
Xrin_reg_6_ DFCNQD1BWP7T $PINS D=n4102 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<6>
Xrin_reg_5_ DFCNQD1BWP7T $PINS D=N102 CDN=n3845 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<5>
Xrin_reg_4_ DFCNQD1BWP7T $PINS D=N101 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<4>
Xrin_reg_3_ DFCNQD1BWP7T $PINS D=n4099 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<3>
Xrin_reg_2_ DFCNQD1BWP7T $PINS D=N99 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<2>
Xrin_reg_1_ DFCNQD1BWP7T $PINS D=N98 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<1>
Xl_reg_45_ DFCND0BWP7T $PINS D=n3051 Q=l<45> CDN=n3844 QN=n2402 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_51_ DFCND0BWP7T $PINS D=n3068 Q=l<51> CDN=n3847 QN=n2390 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_58_ DFCND0BWP7T $PINS D=n3069 Q=l<58> CDN=n3847 QN=n2388 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_59_ DFCND1BWP7T $PINS D=n3087 Q=l<59> CDN=n3847 QN=n2401 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_116_ DFCND0BWP7T $PINS D=n3584 Q=l<116> CDN=n3847 QN=n2399 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_122_ DFCND0BWP7T $PINS D=n4366 Q=l<122> CDN=n3847 QN=n2387 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_123_ DFCND1BWP7T $PINS D=n3088 Q=l<123> CDN=n3847 QN=n2400 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_42_ DFCND0BWP7T $PINS D=n3052 Q=l<42> CDN=n3850 QN=n2369 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_49_ DFCND2BWP7T $PINS D=n1103 Q=l<49> CDN=n3844 QN=n2370 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_50_ DFCND0BWP7T $PINS D=n4414 Q=l<50> CDN=n3844 QN=n2374 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_57_ DFCND0BWP7T $PINS D=n4369 Q=l<57> CDN=n3850 QN=n2375 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_115_ DFCND0BWP7T $PINS D=n3071 Q=l<115> CDN=n3848 QN=n2386 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_112_ DFCND0BWP7T $PINS D=n3077 Q=l<112> CDN=n3848 QN=n2350 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_119_ DFCND0BWP7T $PINS D=n1125 Q=l<119> CDN=n3848 QN=n2351 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_96_ DFCND0BWP7T $PINS D=n1164 Q=l<96> CDN=n3844 QN=n2318 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_53_ DFCND0BWP7T $PINS D=n3455 Q=l<53> CDN=n3850 QN=n2321 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_60_ DFCND2BWP7T $PINS D=n3577 Q=l<60> CDN=n3850 QN=n2322 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_103_ DFCND2BWP7T $PINS D=n3049 Q=l<103> CDN=n3844 QN=n2317 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_124_ DFCND1BWP7T $PINS D=n4288 Q=l<124> CDN=n3850 QN=n2320 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_56_ DFCND2BWP7T $PINS D=n4285 Q=l<56> CDN=n3844 QN=n2368 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_63_ DFCND0BWP7T $PINS D=n1105 Q=l<63> CDN=n3850 QN=n2367 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_113_ DFCND2BWP7T $PINS D=n4367 Q=l<113> CDN=n3844 QN=n2364 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_120_ DFCND2BWP7T $PINS D=n1107 Q=l<120> CDN=n3844 QN=n2365 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_127_ DFCND1BWP7T $PINS D=n3580 Q=l<127> CDN=n3850 QN=n2366 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_40_ DFCND0BWP7T $PINS D=n3058 Q=l<40> CDN=n3848 QN=n2340 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_54_ DFCND0BWP7T $PINS D=n3078 Q=l<54> CDN=n3846 QN=n2339 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_61_ DFCND0BWP7T $PINS D=n3458 Q=l<61> CDN=n3846 QN=n2338 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_111_ DFCND0BWP7T $PINS D=n1144 Q=l<111> CDN=n3851 QN=n2335 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_118_ DFCND0BWP7T $PINS D=n3064 Q=l<118> CDN=n3850 QN=n2336 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_125_ DFCND0BWP7T $PINS D=n4370 Q=l<125> CDN=n3846 QN=n2337 CP=clk_G1B4I4
+ VSS=VSS VDD=VDD
Xl_reg_55_ DFCND0BWP7T $PINS D=n1122 Q=l<55> CDN=n3848 QN=n2354 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_126_ DFCND2BWP7T $PINS D=n1124 Q=l<126> CDN=n3847 QN=n2352 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xrin_reg_33_ DFCND0BWP7T $PINS D=N130 Q=rin<33> CDN=n3847 CP=clk_G1B4I3 VSS=VSS
+ VDD=VDD
Xl_reg_21_ DFCND0BWP7T $PINS D=n1099 Q=l<21> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_29_ DFCND2BWP7T $PINS D=n1087 Q=l<29> CDN=n3845 QN=n2376 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_83_ DFCND2BWP7T $PINS D=n1130 Q=l<83> CDN=n3848 QN=n2347 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_5_ DFCND0BWP7T $PINS D=n2963 Q=l<5> CDN=n3847 QN=n2345 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_13_ DFCND1BWP7T $PINS D=n1116 Q=l<13> CDN=n3847 QN=n2358 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_14_ DFCND0BWP7T $PINS D=n1098 Q=l<14> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_76_ DFCND2BWP7T $PINS D=n1131 CDN=n3847 QN=n2348 CP=clk_G1B4I3 VSS=VSS
+ VDD=VDD
Xl_reg_4_ DFCND0BWP7T $PINS D=n3571 Q=l<4> CDN=n3847 QN=n2328 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_12_ DFCND0BWP7T $PINS D=n3575 Q=l<12> CDN=n3847 QN=n2344 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_92_ DFCND0BWP7T $PINS D=n1111 Q=l<92> CDN=n3850 CP=clk_G1B4I4 VSS=VSS
+ VDD=VDD
Xl_reg_3_ DFCND0BWP7T $PINS D=n1047 Q=l<3> CDN=n3847 QN=n2408 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_75_ DFCND1BWP7T $PINS D=n1149 Q=l<75> CDN=n3847 QN=n2331 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_90_ DFCND1BWP7T $PINS D=n1147 Q=l<90> CDN=n3848 QN=n2332 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_66_ DFCND0BWP7T $PINS D=n1064 Q=l<66> CDN=n3847 QN=n2394 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_6_ DFCND0BWP7T $PINS D=n3574 Q=l<6> CDN=n3847 QN=n2359 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_22_ DFCND0BWP7T $PINS D=n1086 Q=l<22> CDN=n3848 QN=n2377 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_67_ DFCND0BWP7T $PINS D=n1046 Q=l<67> CDN=n3847 QN=n2409 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_77_ DFCND0BWP7T $PINS D=n2923 Q=l<77> CDN=n3844 QN=n2362 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_74_ DFCND0BWP7T $PINS D=n1045 CDN=n3847 QN=n2410 CP=clk_G1B4I3 VSS=VSS
+ VDD=VDD
Xl_reg_18_ DFCND1BWP7T $PINS D=n2999 Q=l<18> CDN=n3847 QN=n2326 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_2_ DFCND0BWP7T $PINS D=n4255 Q=l<2> CDN=n3847 QN=n2393 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_78_ DFCND0BWP7T $PINS D=n1167 Q=l<78> CDN=n3851 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_71_ DFCND0BWP7T $PINS D=n1168 Q=l<71> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_64_ DFCND0BWP7T $PINS D=n1169 Q=l<64> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_0_ DFCND0BWP7T $PINS D=n1170 Q=l<0> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_70_ DFCND1BWP7T $PINS D=n4238 Q=l<70> CDN=n3847 QN=n2360 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_10_ DFCND1BWP7T $PINS D=n1048 Q=l<10> CDN=n3847 QN=n2407 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_8_ DFCND0BWP7T $PINS D=n3572 Q=l<8> CDN=n3848 QN=n2379 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_73_ DFCND0BWP7T $PINS D=n2922 Q=l<73> CDN=n3848 QN=n2396 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_80_ DFCND0BWP7T $PINS D=n2864 Q=l<80> CDN=n3848 QN=n2395 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_26_ DFCND0BWP7T $PINS D=n1136 Q=l<26> CDN=n3848 QN=n2342 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_79_ DFCND0BWP7T $PINS D=n1080 CDN=n3851 QN=n2384 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_65_ DFCND0BWP7T $PINS D=n1082 CDN=n3847 QN=n2381 CP=clk_G1B4I3 VSS=VSS
+ VDD=VDD
Xl_reg_17_ DFCND0BWP7T $PINS D=n1049 Q=l<17> CDN=n3847 QN=n2406 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_9_ DFCND0BWP7T $PINS D=n1066 Q=l<9> CDN=n3848 QN=n2392 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_81_ DFCND2BWP7T $PINS D=n1044 Q=l<81> CDN=n3847 QN=n2412 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_88_ DFCND0BWP7T $PINS D=n1043 CDN=n3844 QN=n2411 CP=clk_G1B4I3 VSS=VSS
+ VDD=VDD
Xl_reg_1_ DFCND0BWP7T $PINS D=n1083 Q=l<1> CDN=n3847 QN=n2380 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_25_ DFCND1BWP7T $PINS D=n1154 Q=l<25> CDN=n3847 QN=n2325 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_7_ DFCND1BWP7T $PINS D=n1097 Q=l<7> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_72_ DFCND0BWP7T $PINS D=n2865 Q=l<72> CDN=n3848 QN=n2382 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_15_ DFCND0BWP7T $PINS D=n3576 Q=l<15> CDN=n3848 QN=n2378 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_31_ DFCND0BWP7T $PINS D=n1051 Q=l<31> CDN=n3844 QN=n2404 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xrin_reg_127_ DFCNQD1BWP7T $PINS D=N224 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<127>
Xrin_reg_123_ DFCNQD1BWP7T $PINS D=N220 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<123>
Xrin_reg_122_ DFCNQD1BWP7T $PINS D=N219 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<122>
Xrin_reg_121_ DFCNQD1BWP7T $PINS D=N218 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<121>
Xrin_reg_120_ DFCNQD2BWP7T $PINS D=N217 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<120>
Xrin_reg_119_ DFCNQD1BWP7T $PINS D=N216 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<119>
Xrin_reg_118_ DFCNQD1BWP7T $PINS D=N215 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<118>
Xrin_reg_117_ DFCNQD2BWP7T $PINS D=N214 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<117>
Xrin_reg_116_ DFCNQD2BWP7T $PINS D=N213 CDN=n3850 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<116>
Xrin_reg_115_ DFCNQD1BWP7T $PINS D=N212 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<115>
Xrin_reg_114_ DFCNQD1BWP7T $PINS D=N211 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<114>
Xrin_reg_112_ DFCNQD1BWP7T $PINS D=N209 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<112>
Xrin_reg_111_ DFCNQD1BWP7T $PINS D=N208 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<111>
Xrin_reg_110_ DFCNQD1BWP7T $PINS D=N207 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<110>
Xrin_reg_108_ DFCNQD1BWP7T $PINS D=N205 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<108>
Xrin_reg_106_ DFCNQD1BWP7T $PINS D=N203 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<106>
Xrin_reg_104_ DFCNQD1BWP7T $PINS D=N201 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<104>
XU1910 OAI211D2BWP7T $PINS A2=n1296 ZN=rk1<0> A1=n4021 B=n1295 VDD=VDD C=n1294
+ VSS=VSS
XU1909 AOI22D1BWP7T $PINS B1=n4017 A2=n3999 ZN=n1294 A1=n1293 VDD=VDD B2=n1292
+ VSS=VSS
XU1908 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1293 A2=n3723 ZN=n1292
XU1900 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3874 A2=n1289 Z=n1293
XU1899 AOI22D1BWP7T $PINS B1=n3972 A2=n1288 ZN=n1295 A1=n3983 VDD=VDD B2=n1289
+ VSS=VSS
XU1892 MUX2ND0BWP7T $PINS ZN=n1296 I1=n1285 I0=n4329 S=n1288 VDD=VDD VSS=VSS
XU1891 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3873 A2=n1289 Z=n1288
XU1889 AOI22D0BWP7T $PINS B1=n1759 A2=n1613 ZN=n1284 A1=n3853 VDD=VDD B2=n1039
+ VSS=VSS
XU1882 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3858 ZN=n1496 A2=n2315
XU1877 INVD0BWP7T $PINS ZN=n1285 VSS=VSS VDD=VDD I=n4329
XU1868 ND2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3853 ZN=n1612 A2=n2312
XU1866 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1681 ZN=n1039 A2=n1762
XU1844 AO222D0BWP7T $PINS Z=N129 C2=n4049 C1=rout<32> B1=n4014 A2=n4446
+ A1=n3994 VDD=VDD B2=k<32> VSS=VSS
XU1826 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n2314 ZN=n1581 A2=n2315
XU1825 NR2XD0BWP7T $PINS VSS=VSS VDD=VDD A1=n2312 ZN=n2307 A2=n1762
XU1819 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n1762 ZN=n3683 A2=n1409
XU1763 INVD1BWP7T $PINS ZN=n2285 VSS=VSS VDD=VDD I=rout<84>
XU1720 INVD0BWP7T $PINS ZN=n2281 VSS=VSS VDD=VDD I=rout<20>
XU1698 INVD0BWP7T $PINS ZN=n1253 VSS=VSS VDD=VDD I=k<13>
XU1695 INVD0BWP7T $PINS ZN=n1329 VSS=VSS VDD=VDD I=k<4>
XU1686 INVD0BWP7T $PINS ZN=n1247 VSS=VSS VDD=VDD I=k<3>
XU1680 INVD0BWP7T $PINS ZN=n1244 VSS=VSS VDD=VDD I=n4380
XU1677 INVD0BWP7T $PINS ZN=n1243 VSS=VSS VDD=VDD I=k<5>
XU1671 INVD0BWP7T $PINS ZN=n1240 VSS=VSS VDD=VDD I=k<53>
XU1668 INVD0BWP7T $PINS ZN=n1238 VSS=VSS VDD=VDD I=k<50>
XU1653 INVD0BWP7T $PINS ZN=n1234 VSS=VSS VDD=VDD I=k<8>
XU1650 INVD0BWP7T $PINS ZN=n1233 VSS=VSS VDD=VDD I=n4381
XU1647 INVD0BWP7T $PINS ZN=n1232 VSS=VSS VDD=VDD I=n4400
XU1632 INVD0BWP7T $PINS ZN=n1224 VSS=VSS VDD=VDD I=k<2>
XU1608 INVD0BWP7T $PINS ZN=n1219 VSS=VSS VDD=VDD I=k<6>
XU1593 INVD0BWP7T $PINS ZN=n1214 VSS=VSS VDD=VDD I=n4459
XU1584 INVD0BWP7T $PINS ZN=n1209 VSS=VSS VDD=VDD I=k<18>
XU1572 INVD0BWP7T $PINS ZN=n1202 VSS=VSS VDD=VDD I=k<38>
XU1554 INVD0BWP7T $PINS ZN=n1195 VSS=VSS VDD=VDD I=k<9>
XU1542 INVD0BWP7T $PINS ZN=n1191 VSS=VSS VDD=VDD I=k<25>
XU1511 INVD0BWP7T $PINS ZN=n1176 VSS=VSS VDD=VDD I=k<20>
Xrin_reg_0_ DFCND0BWP7T $PINS D=N97 Q=rin<0> CDN=n3848 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_34_ DFCND0BWP7T $PINS D=n1119 Q=l<34> CDN=n3848 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_35_ DFCND1BWP7T $PINS D=n1101 Q=l<35> CDN=n3850 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_99_ DFCND0BWP7T $PINS D=n1110 Q=l<99> CDN=n3850 CP=clk_G1B4I4 VSS=VSS
+ VDD=VDD
Xl_reg_102_ DFCND0BWP7T $PINS D=n1059 Q=l<102> CDN=n3844 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_106_ DFCND2BWP7T $PINS D=n1109 Q=l<106> CDN=n3850 QN=n2363 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_108_ DFCND0BWP7T $PINS D=n1076 Q=l<108> CDN=n3845 QN=n2385 CP=clk_G1B4I2
+ VSS=VSS VDD=VDD
Xl_reg_37_ DFCND0BWP7T $PINS D=n1070 Q=l<37> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_33_ DFCND1BWP7T $PINS D=n1137 Q=l<33> CDN=n3848 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_39_ DFCND2BWP7T $PINS D=n1156 Q=l<39> CDN=n3844 QN=n2323 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_46_ DFCND1BWP7T $PINS D=n1157 Q=l<46> CDN=n3844 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_97_ DFCND0BWP7T $PINS D=n1146 Q=l<97> CDN=n3848 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_110_ DFCND1BWP7T $PINS D=n1162 Q=l<110> CDN=n3844 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_117_ DFCND2BWP7T $PINS D=n1161 Q=l<117> CDN=n3850 QN=n2319 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
XU2080 MUX2ND1BWP7T $PINS ZN=n1394 I1=n3798 I0=n3797 S=n1396 VDD=VDD VSS=VSS
XU2077 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<75> A2=n3626 ZN=n1396
XU2074 AO221D0BWP7T $PINS Z=n1389 C=n3981 B1=n1388 A2=n3969 A1=n1583 VDD=VDD
+ B2=n1723 VSS=VSS
XU2072 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1386 ZN=rk1<10> A2=n4020 A1=n1387
XU2071 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n1810 A2=n1385 A1=n3985 ZN=n1386
+ C=n1384
XU2069 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1382 A2=n3726 Z=n1383
XU2068 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<10> A2=n4008 Z=n1382
XU2066 MAOI22D0BWP7T $PINS A2=n1385 ZN=n1387 A1=n4460 B2=n1385 VDD=VDD B1=n4460
+ VSS=VSS
XU2065 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4008 A2=n3871 Z=n1385
XU2061 OAI211D2BWP7T $PINS A2=n3982 ZN=rk1<9> A1=n1379 B=n1378 VDD=VDD C=n1802
+ VSS=VSS
XU2060 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1802 A2=n3117
XU2059 AOI21D1BWP7T $PINS VSS=VSS A2=n1377 VDD=VDD A1=n4020 B=n1376 ZN=n1378
XU2058 OAI22D2BWP7T $PINS B1=n1374 A2=n4016 ZN=n1376 A1=n1375 VDD=VDD B2=n4000
+ VSS=VSS
XU2057 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1374 A2=k<9> Z=n1375
XU2056 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<9> A2=n3117 ZN=n1374
XU2055 MUX2ND0BWP7T $PINS ZN=n1377 I1=n2007 I0=n4307 S=n1379 VDD=VDD VSS=VSS
XU2054 INVD0BWP7T $PINS ZN=n2007 VSS=VSS VDD=VDD I=k<73>
XU2053 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<73> A2=n3117 ZN=n1379
XU2052 OAI211D1BWP7T $PINS A2=n1373 ZN=n1794 A1=n3859 B=n1372 VDD=VDD C=n1371
+ VSS=VSS
XU2049 INVD0BWP7T $PINS ZN=n1370 VSS=VSS VDD=VDD I=n1593
XU2043 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1445 A2=n1367 A1=n3985 ZN=n1368
+ C=n1366
XU2042 OAI22D1BWP7T $PINS B1=n1364 A2=n4016 ZN=n1366 A1=n1365 VDD=VDD B2=n4000
+ VSS=VSS
XU2041 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1364 A2=k<8> Z=n1365
XU2040 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3296 A2=l<8> Z=n1364
XU2037 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<72> A2=n2622 Z=n1367
XU2034 OAI211D1BWP7T $PINS A2=n1409 ZN=n1362 A1=n1681 B=n1596 VDD=VDD C=n1679
+ VSS=VSS
XU2033 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3969 ZN=n1679 A2=n1528
XU2032 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3979 ZN=n1596 A2=n2312
XU2029 INVD0BWP7T $PINS ZN=n2004 VSS=VSS VDD=VDD I=k<72>
XU2028 OAI211D0BWP7T $PINS A2=n1361 ZN=rk1<7> A1=n4021 B=n1360 VDD=VDD C=n1359
+ VSS=VSS
XU2027 AOI22D0BWP7T $PINS B1=n4017 A2=n3999 ZN=n1359 A1=n1358 VDD=VDD B2=n1357
+ VSS=VSS
XU2026 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1358 A2=n3725 ZN=n1357
XU2025 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<7> A2=n1355 Z=n1358
XU2024 AOI22D1BWP7T $PINS B1=n3972 A2=n1354 ZN=n1360 A1=n3983 VDD=VDD B2=n1355
+ VSS=VSS
XU2023 MUX2ND0BWP7T $PINS ZN=n1361 I1=n2001 I0=n4383 S=n1354 VDD=VDD VSS=VSS
XU2022 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3872 A2=n1355 Z=n1354
XU2020 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1400 A2=n3977 A1=n3975 ZN=n1353
+ C=n1411
XU2019 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n1373 ZN=n1411 A2=n3980
XU2015 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=round<3> ZN=n2308 A2=n3986
XU2012 CKND0BWP7T $PINS ZN=n2001 VSS=VSS VDD=VDD I=n4383
XU2011 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1351 ZN=rk1<6> A2=n4020 A1=n1352
XU2010 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1949 A2=n1350 A1=n3985 ZN=n1351
+ C=n1349
XU2009 OAI22D1BWP7T $PINS B1=n1347 A2=n3648 ZN=n1349 A1=n1348 VDD=VDD B2=n4000
+ VSS=VSS
XU2008 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1347 A2=k<6> Z=n1348
XU2007 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4373 A2=l<6> Z=n1347
XU2004 MAOI22D0BWP7T $PINS A2=n1350 ZN=n1352 A1=n3796 B2=n1350 VDD=VDD B1=n3796
+ VSS=VSS
XU2003 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<70> A2=n4010 Z=n1350
XU1997 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3858 ZN=n1344 A2=n1407
XU1996 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n2314 ZN=n1345 A2=n1681
XU1995 INVD1BWP7T $PINS ZN=n1388 VSS=VSS VDD=VDD I=n1496
XU1994 OAI211D1BWP7T $PINS A2=n3984 ZN=rk1<5> A1=n1342 B=n1341 VDD=VDD C=n1578
+ VSS=VSS
XU1993 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1578 A2=n4372
XU1992 AOI21D0BWP7T $PINS VSS=VSS A2=n1340 VDD=VDD A1=n4020 B=n1339 ZN=n1341
XU1989 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1337 A2=k<5> Z=n1338
XU1988 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<5> A2=n3359 ZN=n1337
XU1987 MUX2ND0BWP7T $PINS ZN=n1340 I1=n3795 I0=n3794 S=n1342 VDD=VDD VSS=VSS
XU1985 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<69> A2=n4372 ZN=n1342
XU1983 AN4D1BWP7T $PINS VSS=VSS A1=n1726 VDD=VDD A2=n1593 A3=n1509 A4=n1549
+ Z=n1335
XU1982 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n3853 A1=round<3> ZN=n1549 A3=n3852
XU1981 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3969 ZN=n1509 A2=n3858
XU1979 AOI22D1BWP7T $PINS B1=n4017 A2=n3999 ZN=n1332 A1=n1331 VDD=VDD B2=n1330
+ VSS=VSS
XU1978 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1331 A2=n1329 ZN=n1330
XU1977 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<4> A2=n4025 ZN=n1331
XU1976 MAOI22D0BWP7T $PINS A2=n1327 ZN=n1333 A1=n3985 B2=n4025 VDD=VDD B1=n3973
+ VSS=VSS
XU1974 MUX2ND0BWP7T $PINS ZN=n1334 I1=n3793 I0=n3792 S=n1327 VDD=VDD VSS=VSS
XU1973 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4025 A2=n2329 Z=n1327
XU1965 OAI22D1BWP7T $PINS B1=n1321 A2=n4016 ZN=n1323 A1=n1322 VDD=VDD B2=n4000
+ VSS=VSS
XU1963 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1321 A2=k<3> Z=n1322
XU1962 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3169 A2=l<3> Z=n1321
XU1960 MUX2ND0BWP7T $PINS ZN=n1326 I1=n1985 I0=n4382 S=n1324 VDD=VDD VSS=VSS
XU1959 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<67> A2=n2584 Z=n1324
XU1953 CKND0BWP7T $PINS ZN=n1985 VSS=VSS VDD=VDD I=k<67>
XU1946 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1312 A2=k<2> Z=n1313
XU1945 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4043 A2=l<2> Z=n1312
XU1941 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<66> A2=n4044 Z=n1315
XU1937 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1308 A2=n3859 A1=n1759 ZN=n1309
+ C=n1408
XU1936 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2315 ZN=n1408 A2=n1593
XU1935 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1625 ZN=n1593 A2=round<2>
XU1934 AOI21D0BWP7T $PINS VSS=VSS A2=n1508 VDD=VDD A1=n1496 B=n3852 ZN=n1308
XU1932 CKND0BWP7T $PINS ZN=n1982 VSS=VSS VDD=VDD I=n4453
XU1929 AOI22D0BWP7T $PINS B1=n4017 A2=n3999 ZN=n1305 A1=n1304 VDD=VDD B2=n1303
+ VSS=VSS
XU1928 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1304 A2=n3724 ZN=n1303
XU1927 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<1> A2=n1302 Z=n1304
XU1926 AOI22D0BWP7T $PINS B1=n3972 A2=n1301 ZN=n1306 A1=n3985 VDD=VDD B2=n1302
+ VSS=VSS
XU1925 MUX2ND0BWP7T $PINS ZN=n1307 I1=n3791 I0=n3790 S=n1301 VDD=VDD VSS=VSS
XU1924 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2776 A2=n1302 ZN=n1301
XU1922 NR4D1BWP7T $PINS VSS=VSS A4=n1400 VDD=VDD ZN=n1299 A3=n1582 A2=n1298
+ A1=n1641
XU1918 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3858 ZN=n1298 A2=n1612
XU1912 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=round<3> ZN=n1508 A2=n2312
XU2225 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1866 A2=n1516 A1=n3983 ZN=n1517
+ C=n1515
XU2224 OAI22D1BWP7T $PINS B1=n1513 A2=n4016 ZN=n1515 A1=n1514 VDD=VDD B2=n3998
+ VSS=VSS
XU2223 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1513 A2=n3740 Z=n1514
XU2222 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<23> A2=n1862 Z=n1513
XU2220 MUX2ND1BWP7T $PINS ZN=n1518 I1=n2048 I0=n4310 S=n1516 VDD=VDD VSS=VSS
XU2219 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1862 A2=n3880 ZN=n1516
XU2217 OAI211D2BWP7T $PINS A2=n3976 ZN=n1511 A1=n1726 B=n1510 VDD=VDD C=n1509
+ VSS=VSS
XU2214 INVD0BWP7T $PINS ZN=n2048 VSS=VSS VDD=VDD I=k<87>
XU2213 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1505 A1=n4021 ZN=rk1<22> A2=n1506
XU2212 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1855 A2=n1504 A1=n3983 ZN=n1505
+ C=n1503
XU2210 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1501 A2=n3738 Z=n1502
XU2209 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3870 A2=n4072 ZN=n1501
XU2207 MUX2ND0BWP7T $PINS ZN=n1506 I1=n2045 I0=k<86> S=n1504 VDD=VDD VSS=VSS
XU2206 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2383 A2=n4073 Z=n1504
XU2203 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3977 A1=n3967 ZN=n1499 A2=n1654
XU2202 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1757 A2=n3859 A1=n3969 ZN=n1500
+ C=n4027
XU2201 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1496 ZN=n1757 A2=n3976
XU2200 INVD0BWP7T $PINS ZN=n2045 VSS=VSS VDD=VDD I=k<86>
XU2199 OAI211D0BWP7T $PINS A2=n3998 ZN=rk1<21> A1=n4075 B=n1494 VDD=VDD C=n1493
+ VSS=VSS
XU2198 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1491 A1=n3736 ZN=n1493 A2=n1492
XU2197 AOI21D0BWP7T $PINS VSS=VSS A2=n1492 VDD=VDD A1=n3736 B=n4016 ZN=n1491
XU2196 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1489 A2=n1490 A1=n3983 ZN=n1494
+ C=n1488
XU2195 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4021 A2=n1490 A1=n3805 ZN=n1488
+ C=n1487
XU2194 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3805 ZN=n1487 A2=n1490
XU2191 IOA22D2BWP7T $PINS A2=n3869 A1=n1485 ZN=n1492 B1=n3869 VSS=VSS B2=n1485
+ VDD=VDD
XU2190 OAI211D1BWP7T $PINS A2=n4000 ZN=rk1<20> A1=n1484 B=n1483 VDD=VDD C=n1482
+ VSS=VSS
XU2189 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1480 A1=n3804 ZN=n1482 A2=n1481
XU2188 AOI21D0BWP7T $PINS VSS=VSS A2=n1481 VDD=VDD A1=n3804 B=n4021 ZN=n1480
XU2187 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1832 A2=n1481 A1=n3985 ZN=n1483
+ C=n1479
XU2186 AOI21D0BWP7T $PINS VSS=VSS A2=n4083 VDD=VDD A1=k<20> B=n1477 ZN=n1479
XU2185 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<20> ZN=n1477 A2=n4083
XU2181 AOI22D1BWP7T $PINS B1=n2357 A2=n3879 ZN=n1484 A1=n1828 VDD=VDD B2=n4024
+ VSS=VSS
XU2179 OAI211D1BWP7T $PINS A2=n3984 ZN=rk1<19> A1=n1475 B=n1474 VDD=VDD C=n1824
+ VSS=VSS
XU2178 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1472 A2=n4280 A1=n3999 ZN=n1474
+ C=n1471
XU2177 AOI21D0BWP7T $PINS VSS=VSS A2=n4365 VDD=VDD A1=n3734 B=n1470 ZN=n1471
XU2176 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3734 ZN=n1470 A2=n4365
XU2175 AOI21D0BWP7T $PINS VSS=VSS A2=n2635 VDD=VDD A1=n3803 B=n1468 ZN=n1472
XU2174 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3803 ZN=n1468 A2=n2635
XU2170 OAI211D0BWP7T $PINS A2=n4000 ZN=rk1<18> A1=n1467 B=n1466 VDD=VDD C=n1465
+ VSS=VSS
XU2169 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1463 A1=n4328 ZN=n1465 A2=n1464
XU2168 AOI21D0BWP7T $PINS VSS=VSS A2=n1464 VDD=VDD A1=n4328 B=n4021 ZN=n1463
XU2167 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1810 A2=n1464 A1=n3985 ZN=n1466
+ C=n1462
XU2166 AOI21D0BWP7T $PINS VSS=VSS A2=n4069 VDD=VDD A1=k<18> B=n1460 ZN=n1462
XU2165 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<18> ZN=n1460 A2=n4069
XU2159 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1456 A2=n1457 A1=n3999 ZN=n1458
+ C=n1455
XU2158 AOI21D0BWP7T $PINS VSS=VSS A2=n1457 VDD=VDD A1=k<17> B=n1454 ZN=n1455
XU2157 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<17> ZN=n1454 A2=n1457
XU2155 AOI21D0BWP7T $PINS VSS=VSS A2=n4093 VDD=VDD A1=n3802 B=n1452 ZN=n1456
XU2154 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3802 ZN=n1452 A2=n4093
XU2149 OAI211D1BWP7T $PINS A2=n4000 ZN=rk1<16> A1=n1451 B=n1450 VDD=VDD C=n1449
+ VSS=VSS
XU2148 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1447 A1=n3732 ZN=n1449 A2=n4090
XU2147 AOI21D0BWP7T $PINS VSS=VSS A2=n4090 VDD=VDD A1=n3732 B=n3648 ZN=n1447
XU2145 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1445 A2=n1446 A1=n3985 ZN=n1450
+ C=n1444
XU2144 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4021 A2=n1446 A1=n3801 ZN=n1444
+ C=n1443
XU2143 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3801 ZN=n1443 A2=n1446
XU2138 AOI22D2BWP7T $PINS B1=n4017 A2=n3999 ZN=n1437 A1=n1436 VDD=VDD B2=n1435
+ VSS=VSS
XU2137 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1436 A2=n3731 ZN=n1435
XU2136 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<15> A2=n1433 ZN=n1436
XU2135 MAOI22D0BWP7T $PINS A2=n1432 ZN=n1438 A1=n3983 B2=n1433 VDD=VDD B1=n3971
+ VSS=VSS
XU2134 MUX2ND0BWP7T $PINS ZN=n1439 I1=n3800 I0=n3799 S=n1432 VDD=VDD VSS=VSS
XU2133 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1433 A2=n2778 Z=n1432
XU2131 OAI211D2BWP7T $PINS A2=n1612 ZN=n1430 A1=n1429 B=n1755 VDD=VDD C=n1593
+ VSS=VSS
XU2126 OAI211D1BWP7T $PINS A2=n1427 ZN=rk1<14> A1=n4021 B=n1426 VDD=VDD C=n1425
+ VSS=VSS
XU2125 AOI22D0BWP7T $PINS B1=n4017 A2=n3999 ZN=n1425 A1=n1424 VDD=VDD B2=n1423
+ VSS=VSS
XU2124 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1424 A2=n3729 ZN=n1423
XU2123 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<14> A2=n1421 Z=n1424
XU2122 AOI22D0BWP7T $PINS B1=n3972 A2=n1420 ZN=n1426 A1=n3983 VDD=VDD B2=n1421
+ VSS=VSS
XU2121 MUX2ND0BWP7T $PINS ZN=n1427 I1=n2024 I0=n4309 S=n1420 VDD=VDD VSS=VSS
XU2120 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1421 A2=l<78> Z=n1420
XU2119 AO221D1BWP7T $PINS Z=n1421 C=n1419 B1=n1654 A2=n1528 A1=n3975 VDD=VDD
+ B2=n1528 VSS=VSS
XU2115 INVD0BWP7T $PINS ZN=n2024 VSS=VSS VDD=VDD I=k<78>
XU2111 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1412 A2=k<13> Z=n1413
XU2110 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1485 A2=l<13> Z=n1412
XU2109 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3973 ZN=n1489 A2=n1485
XU2107 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<77> A2=n4041 Z=n1415
XU2103 INVD0BWP7T $PINS ZN=n1636 VSS=VSS VDD=VDD I=n1408
XU2101 INVD1BWP7T $PINS ZN=n1429 VSS=VSS VDD=VDD I=n1039
XU2100 INVD0BWP7T $PINS ZN=n2020 VSS=VSS VDD=VDD I=k<77>
XU2098 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n1832 A2=n1404 A1=n3985 ZN=n1405
+ C=n1403
XU2097 OAI22D2BWP7T $PINS B1=n1401 A2=n4016 ZN=n1403 A1=n1402 VDD=VDD B2=n4000
+ VSS=VSS
XU2096 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1401 A2=k<12> Z=n1402
XU2095 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<12> A2=n1828 Z=n1401
XU2093 MUX2ND0BWP7T $PINS ZN=n1406 I1=n2016 I0=k<76> S=n1404 VDD=VDD VSS=VSS
XU2092 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1828 A2=n2348 Z=n1404
XU2088 AOI21D2BWP7T $PINS VSS=VSS A2=n3980 VDD=VDD A1=n1723 B=n3853 ZN=n1399
XU2087 INVD0BWP7T $PINS ZN=n2016 VSS=VSS VDD=VDD I=k<76>
XU2086 OAI211D2BWP7T $PINS A2=n3984 ZN=rk1<11> A1=n1396 B=n1395 VDD=VDD C=n1824
+ VSS=VSS
XU2085 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1824 A2=n3626
XU2084 AOI21D1BWP7T $PINS VSS=VSS A2=n1394 VDD=VDD A1=n4020 B=n1393 ZN=n1395
XU2083 OAI22D1BWP7T $PINS B1=n1391 A2=n4016 ZN=n1393 A1=n1392 VDD=VDD B2=n4000
+ VSS=VSS
XU2082 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1391 A2=k<11> Z=n1392
XU2081 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<11> A2=n3626 ZN=n1391
XU2374 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1657 A2=l<100> Z=n1655
XU2372 OAI211D1BWP7T $PINS A2=n3980 ZN=n1652 A1=n1755 B=n4374 VDD=VDD C=n1650
+ VSS=VSS
XU2371 AOI31D1BWP7T $PINS B=n2308 ZN=n1650 A1=n3853 A2=round<2> VDD=VDD
+ A3=n3852 VSS=VSS
XU2369 OAI211D2BWP7T $PINS A2=n1649 ZN=rk0<3> A1=n4021 B=n1648 VDD=VDD C=n1647
+ VSS=VSS
XU2368 AOI22D1BWP7T $PINS B1=n4017 A2=n3999 ZN=n1647 A1=n1646 VDD=VDD B2=n1645
+ VSS=VSS
XU2367 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1646 A2=n3758 ZN=n1645
XU2366 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<35> A2=n1643 ZN=n1646
XU2364 MUX2ND1BWP7T $PINS ZN=n1649 I1=n3816 I0=n3815 S=n1642 VDD=VDD VSS=VSS
XU2363 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4371 A2=l<99> ZN=n1642
XU2361 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3344 ZN=n1638 A2=n1636
XU2359 OAI211D1BWP7T $PINS A2=n1635 ZN=rk0<2> A1=n4021 B=n1634 VDD=VDD C=n1633
+ VSS=VSS
XU2358 AOI22D1BWP7T $PINS B1=n4017 A2=n3999 ZN=n1633 A1=n1632 VDD=VDD B2=n1631
+ VSS=VSS
XU2357 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1632 A2=n3756 ZN=n1631
XU2356 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<34> A2=n1629 Z=n1632
XU2354 MUX2ND0BWP7T $PINS ZN=n1635 I1=n3814 I0=n3813 S=n1628 VDD=VDD VSS=VSS
XU2353 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<98> A2=n1629 Z=n1628
XU2351 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3979 ZN=n1626 A2=n1759
XU2350 OA21D0BWP7T $PINS Z=n1725 A1=n1625 VDD=VDD A2=n1761 VSS=VSS B=n1624
XU2347 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1791 A2=n3286
XU2345 OAI22D1BWP7T $PINS B1=n1618 A2=n3648 ZN=n1620 A1=n1619 VDD=VDD B2=n4000
+ VSS=VSS
XU2343 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<33> A2=n3099 ZN=n1618
XU2342 MUX2ND0BWP7T $PINS ZN=n1621 I1=n3812 I0=n3811 S=n1623 VDD=VDD VSS=VSS
XU2340 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<97> A2=n3285 ZN=n1623
XU2338 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1625 ZN=n1616 A2=n3974
XU2336 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3859 ZN=n1614 A2=n1612
XU2335 OAI211D0BWP7T $PINS A2=n3984 ZN=rk0<0> A1=n1611 B=n1610 VDD=VDD C=n1970
+ VSS=VSS
XU2334 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1608 A2=n1609 A1=n3999 ZN=n1610
+ C=n1607
XU2333 AOI21D0BWP7T $PINS VSS=VSS A2=n1609 VDD=VDD A1=k<32> B=n1606 ZN=n1607
XU2332 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<32> ZN=n1606 A2=n1609
XU2331 AOI21D0BWP7T $PINS VSS=VSS A2=n4091 VDD=VDD A1=n3810 B=n1604 ZN=n1608
XU2330 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3810 ZN=n1604 A2=n4091
XU2326 OAI211D0BWP7T $PINS A2=n3982 ZN=rk1<31> A1=n1603 B=n1602 VDD=VDD C=n1970
+ VSS=VSS
XU2324 AOI21D0BWP7T $PINS VSS=VSS A2=n1601 VDD=VDD A1=n4020 B=n1600 ZN=n1602
XU2323 OAI22D2BWP7T $PINS B1=n1598 A2=n4016 ZN=n1600 A1=n1599 VDD=VDD B2=n3998
+ VSS=VSS
XU2322 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1598 A2=n3752 Z=n1599
XU2320 MUX2ND0BWP7T $PINS ZN=n1601 I1=n2074 I0=n4455 S=n1603 VDD=VDD VSS=VSS
XU2319 INVD0BWP7T $PINS ZN=n2074 VSS=VSS VDD=VDD I=k<95>
XU2313 OAI211D1BWP7T $PINS A2=n3982 ZN=rk1<30> A1=n1592 B=n1591 VDD=VDD C=n1780
+ VSS=VSS
XU2312 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1780 A2=n4061
XU2311 AOI21D0BWP7T $PINS VSS=VSS A2=n1590 VDD=VDD A1=n4020 B=n1589 ZN=n1591
XU2310 OAI22D1BWP7T $PINS B1=n1587 A2=n4016 ZN=n1589 A1=n1588 VDD=VDD B2=n3998
+ VSS=VSS
XU2309 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1587 A2=n3750 Z=n1588
XU2308 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<30> A2=n4065 ZN=n1587
XU2307 MUX2ND0BWP7T $PINS ZN=n1590 I1=n3809 I0=n3808 S=n1592 VDD=VDD VSS=VSS
XU2305 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<94> A2=n4061 ZN=n1592
XU2304 OAI211D2BWP7T $PINS A2=n1755 ZN=n1772 A1=n1681 B=n1586 VDD=VDD C=n1585
+ VSS=VSS
XU2301 OAI211D0BWP7T $PINS A2=n3982 ZN=rk1<29> A1=n1580 B=n1579 VDD=VDD C=n1578
+ VSS=VSS
XU2300 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1576 A2=n1577 A1=n3999 ZN=n1579
+ C=n1575
XU2299 AOI21D0BWP7T $PINS VSS=VSS A2=n4067 VDD=VDD A1=n3807 B=n1573 ZN=n1575
XU2298 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3807 ZN=n1573 A2=n4067
XU2296 AOI21D0BWP7T $PINS VSS=VSS A2=n1577 VDD=VDD A1=n3748 B=n1572 ZN=n1576
XU2295 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3748 ZN=n1572 A2=n1577
XU2288 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1564 A2=n4377 Z=n1565
XU2287 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<28> A2=n4098 Z=n1564
XU2284 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4098 A2=l<92> ZN=n1567
XU2279 INVD0BWP7T $PINS ZN=n2066 VSS=VSS VDD=VDD I=k<92>
XU2277 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1738 A2=n1556 A1=n3983 ZN=n1557
+ C=n1555
XU2276 OAI22D1BWP7T $PINS B1=n1553 A2=n4016 ZN=n1555 A1=n1554 VDD=VDD B2=n3998
+ VSS=VSS
XU2275 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1553 A2=n3746 Z=n1554
XU2274 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1735 A2=l<27> Z=n1553
XU2272 MUX2ND0BWP7T $PINS ZN=n1558 I1=n2063 I0=n4387 S=n1556 VDD=VDD VSS=VSS
XU2271 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<91> A2=n1735 ZN=n1556
XU2268 ND2D0BWP7T $PINS VSS=VSS VDD=VDD A1=n1625 ZN=n1595 A2=n2314
XU2267 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3859 A1=n1654 ZN=n1550 A2=n3981
XU2265 INVD0BWP7T $PINS ZN=n2063 VSS=VSS VDD=VDD I=k<91>
XU2264 OAI211D1BWP7T $PINS A2=n4000 ZN=rk1<26> A1=n1548 B=n1547 VDD=VDD C=n1546
+ VSS=VSS
XU2263 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1544 A1=n3744 ZN=n1546 A2=n4089
XU2262 AOI21D0BWP7T $PINS VSS=VSS A2=n4089 VDD=VDD A1=n3744 B=n4016 ZN=n1544
XU2260 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1542 A2=n1543 A1=n3985 ZN=n1547
+ C=n1541
XU2259 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n4021 A2=n1543 A1=n3806 ZN=n1541
+ C=n1540
XU2258 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3806 ZN=n1540 A2=n1543
XU2254 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1890 A2=n1535 A1=n3983 ZN=n1536
+ C=n1534
XU2252 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1532 A2=k<25> Z=n1533
XU2251 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<25> A2=n3120 ZN=n1532
XU2249 MUX2ND0BWP7T $PINS ZN=n1537 I1=n2055 I0=k<89> S=n1535 VDD=VDD VSS=VSS
XU2248 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2316 A2=n4064 Z=n1535
XU2246 OAI211D2BWP7T $PINS A2=n1754 ZN=n1884 A1=n3859 B=n1531 VDD=VDD C=n1627
+ VSS=VSS
XU2245 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3974 ZN=n1627 A2=n3852
XU2242 INVD0BWP7T $PINS ZN=n2055 VSS=VSS VDD=VDD I=k<89>
XU2240 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1878 A2=n1524 A1=n3983 ZN=n1525
+ C=n1523
XU2238 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1521 A2=n3742 Z=n1522
XU2237 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<24> A2=n4039 ZN=n1521
XU2235 MUX2ND0BWP7T $PINS ZN=n1526 I1=n2051 I0=n4386 S=n1524 VDD=VDD VSS=VSS
XU2234 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2781 A2=n4040 Z=n1524
XU2232 OAI211D1BWP7T $PINS A2=n1762 ZN=n1872 A1=n1527 B=n1597 VDD=VDD C=n1520
+ VSS=VSS
XU2229 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1559 ZN=n1527 A2=n3967
XU2227 INVD0BWP7T $PINS ZN=n2051 VSS=VSS VDD=VDD I=k<88>
XU2226 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1517 A1=n4021 ZN=rk1<23> A2=n1518
XU2523 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3834 ZN=n1818 A2=n4080
XU2519 OAI211D1BWP7T $PINS A2=n4000 ZN=rk0<18> A1=n1815 B=n1814 VDD=VDD C=n1813
+ VSS=VSS
XU2518 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1811 A1=n3833 ZN=n1813 A2=n4281
XU2517 AOI21D0BWP7T $PINS VSS=VSS A2=n1812 VDD=VDD A1=n3833 B=n4021 ZN=n1811
XU2516 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1810 A2=n4281 A1=n3985 ZN=n1814
+ C=n1809
XU2515 AOI21D0BWP7T $PINS VSS=VSS A2=n4070 VDD=VDD A1=k<50> B=n1807 ZN=n1809
XU2514 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<50> ZN=n1807 A2=n4070
XU2510 OAI211D0BWP7T $PINS A2=n3982 ZN=rk0<17> A1=n1804 B=n1803 VDD=VDD C=n1802
+ VSS=VSS
XU2509 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1800 A2=n4439 A1=n3999 ZN=n1803
+ C=n1799
XU2508 AOI21D0BWP7T $PINS VSS=VSS A2=n4439 VDD=VDD A1=k<49> B=n1798 ZN=n1799
XU2507 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<49> ZN=n1798 A2=n1801
XU2506 AOI21D1BWP7T $PINS VSS=VSS A2=n4097 VDD=VDD A1=n3832 B=n1796 ZN=n1800
XU2505 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3832 ZN=n1796 A2=n4097
XU2501 OAI211D1BWP7T $PINS A2=n3982 ZN=rk0<16> A1=n1793 B=n1792 VDD=VDD C=n1791
+ VSS=VSS
XU2500 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1789 A2=n1790 A1=n3999 ZN=n1792
+ C=n1788
XU2499 AOI21D0BWP7T $PINS VSS=VSS A2=n4086 VDD=VDD A1=n3831 B=n1786 ZN=n1788
XU2498 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3831 ZN=n1786 A2=n4086
XU2496 AOI21D0BWP7T $PINS VSS=VSS A2=n1790 VDD=VDD A1=n3770 B=n1785 ZN=n1789
XU2495 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3770 ZN=n1785 A2=n1790
XU2491 OAI211D1BWP7T $PINS A2=n3982 ZN=rk0<15> A1=n1782 B=n1781 VDD=VDD C=n1780
+ VSS=VSS
XU2490 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1778 A2=n1779 A1=n3999 ZN=n1781
+ C=n1777
XU2488 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3830 ZN=n1775 A2=n4106
XU2486 AOI21D0BWP7T $PINS VSS=VSS A2=n1779 VDD=VDD A1=n3768 B=n1774 ZN=n1778
XU2485 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3768 ZN=n1774 A2=n1779
XU2481 OAI211D2BWP7T $PINS A2=n3982 ZN=rk0<14> A1=n1771 B=n4265 VDD=VDD C=n1942
+ VSS=VSS
XU2480 ND2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1942 A2=n4048
XU2479 AOI21D1BWP7T $PINS VSS=VSS A2=n1768 VDD=VDD A1=n4020 B=n1767 ZN=n1770
XU2477 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1765 A2=k<46> Z=n1766
XU2476 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<46> A2=n4048 ZN=n1765
XU2475 MUX2ND0BWP7T $PINS ZN=n1768 I1=n3829 I0=n4389 S=n1771 VDD=VDD VSS=VSS
XU2474 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<110> A2=n4048 ZN=n1771
XU2471 OAI22D1BWP7T $PINS B1=n1754 A2=n1755 ZN=n1756 A1=round<1> VDD=VDD
+ B2=n3980 VSS=VSS
XU2469 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1748 A1=k<109> ZN=n1750 A2=n4357
XU2468 AOI21D0BWP7T $PINS VSS=VSS A2=n4357 VDD=VDD A1=k<109> B=n4021 ZN=n1748
XU2467 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1925 A2=n4357 A1=n3983 ZN=n1751
+ C=n1747
XU2466 AOI21D1BWP7T $PINS VSS=VSS A2=n4107 VDD=VDD A1=k<45> B=n1745 ZN=n1747
XU2465 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<45> ZN=n1745 A2=n4107
XU2459 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1740 A1=n3766 ZN=n1742 A2=n4094
XU2458 AOI21D0BWP7T $PINS VSS=VSS A2=n4094 VDD=VDD A1=n3766 B=n4016 ZN=n1740
XU2454 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3828 ZN=n1736 A2=n1739
XU2450 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1732 ZN=rk0<11> A2=n4020 A1=n1733
XU2449 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1901 A2=n1731 A1=n3983 ZN=n1732
+ C=n1730
XU2447 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1728 A2=n3764 Z=n1729
XU2446 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2582 A2=l<43> Z=n1728
XU2445 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1901 A2=n2582
XU2443 MAOI22D0BWP7T $PINS A2=n1731 ZN=n1733 A1=n3826 B2=n1731 VDD=VDD B1=n3826
+ VSS=VSS
XU2442 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<107> A2=n3318 Z=n1731
XU2440 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n2315 A1=n3977 ZN=n1724 A3=n1723
XU2439 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<10> A1=n1722 B=n1721 VDD=VDD C=n1720
+ VSS=VSS
XU2438 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1718 A1=n3825 ZN=n1720 A2=n1719
XU2437 AOI21D0BWP7T $PINS VSS=VSS A2=n1719 VDD=VDD A1=n3825 B=n4021 ZN=n1718
XU2436 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1890 A2=n1719 A1=n3983 ZN=n1721
+ C=n1717
XU2435 AOI21D1BWP7T $PINS VSS=VSS A2=n4103 VDD=VDD A1=n4320 B=n1715 ZN=n1717
XU2434 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n4320 ZN=n1715 A2=n4103
XU2428 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1710 A1=n3824 ZN=n1712 A2=n1711
XU2427 AOI21D0BWP7T $PINS VSS=VSS A2=n1711 VDD=VDD A1=n3824 B=n4021 ZN=n1710
XU2426 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1878 A2=n1711 A1=n3983 ZN=n1713
+ C=n1709
XU2425 AOI21D0BWP7T $PINS VSS=VSS A2=n4087 VDD=VDD A1=n3762 B=n1707 ZN=n1709
XU2424 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3762 ZN=n1707 A2=n4087
XU2420 OAI211D2BWP7T $PINS A2=n3998 ZN=rk0<8> A1=n1706 B=n1705 VDD=VDD C=n1704
+ VSS=VSS
XU2419 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1702 A1=n3823 ZN=n1704 A2=n1703
XU2418 AOI21D0BWP7T $PINS VSS=VSS A2=n1703 VDD=VDD A1=n3823 B=n4021 ZN=n1702
XU2417 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1866 A2=n1703 A1=n3983 ZN=n1705
+ C=n1701
XU2416 AOI21D0BWP7T $PINS VSS=VSS A2=n4081 VDD=VDD A1=n4393 B=n1699 ZN=n1701
XU2415 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n4393 ZN=n1699 A2=n4081
XU2410 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<7> A1=n1698 B=n1697 VDD=VDD C=n1696
+ VSS=VSS
XU2409 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1694 A1=n3822 ZN=n1696 A2=n1695
XU2408 AOI21D0BWP7T $PINS VSS=VSS A2=n1695 VDD=VDD A1=n3822 B=n4021 ZN=n1694
XU2407 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1855 A2=n1695 A1=n3983 ZN=n1697
+ C=n1693
XU2406 AOI21D0BWP7T $PINS VSS=VSS A2=n2651 VDD=VDD A1=k<39> B=n1691 ZN=n1693
XU2405 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<39> ZN=n1691 A2=n2651
XU2401 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1689 ZN=rk0<6> A2=n4020 A1=n1690
XU2400 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1843 A2=n1688 A1=n3983 ZN=n1689
+ C=n1687
XU2399 OAI22D1BWP7T $PINS B1=n1685 A2=n4016 ZN=n1687 A1=n1686 VDD=VDD B2=n3998
+ VSS=VSS
XU2398 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1685 A2=k<38> Z=n1686
XU2397 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4046 A2=l<38> Z=n1685
XU2396 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1843 A2=n4046
XU2395 MAOI22D0BWP7T $PINS A2=n1688 ZN=n1690 A1=n3821 B2=n1688 VDD=VDD B1=n3821
+ VSS=VSS
XU2394 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=l<102> A2=n4046 ZN=n1688
XU2389 AOI22D1BWP7T $PINS B1=n4017 A2=n3999 ZN=n1674 A1=n1673 VDD=VDD B2=n1672
+ VSS=VSS
XU2388 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1673 A2=n3761 ZN=n1672
XU2387 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4463 A2=n1670 ZN=n1673
XU2386 MAOI22D0BWP7T $PINS A2=n1668 ZN=n1675 A1=n3983 B2=n4291 VDD=VDD B1=n3973
+ VSS=VSS
XU2385 MUX2ND0BWP7T $PINS ZN=n1676 I1=n3820 I0=n3819 S=n1668 VDD=VDD VSS=VSS
XU2384 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4291 A2=l<101> ZN=n1668
XU2380 OAI211D1BWP7T $PINS A2=n1663 ZN=rk0<4> A1=n4021 B=n1662 VDD=VDD C=n1661
+ VSS=VSS
XU2379 AOI22D0BWP7T $PINS B1=n4017 A2=n3999 ZN=n1661 A1=n1660 VDD=VDD B2=n1659
+ VSS=VSS
XU2378 XNR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1660 A2=n3759 ZN=n1659
XU2377 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3881 A2=n1657 Z=n1660
XU2375 MUX2ND0BWP7T $PINS ZN=n1663 I1=n3818 I0=n3817 S=n1655 VDD=VDD VSS=VSS
XU2707 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2034 A1=n4397 VDD=VDD B2=n3964
+ VSS=VSS
XU2706 MAOI22D2BWP7T $PINS A2=p<17> ZN=n2035 A1=n3802 B2=p<17> VDD=VDD B1=n3802
+ VSS=VSS
XU2705 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2032 ZN=N113 A2=n3992 A1=n2033
XU2704 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2032 A1=n3732 VDD=VDD B2=n3934
+ VSS=VSS
XU2697 MAOI22D1BWP7T $PINS A2=n3800 ZN=n2029 A1=p<15> B2=p<15> VDD=VDD B1=n3800
+ VSS=VSS
XU2694 IAO22D2BWP7T $PINS A2=p<14> ZN=n2026 A1=n2024 B2=n2024 VDD=VDD B1=p<14>
+ VSS=VSS
XU2692 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2022 A1=n4392 VDD=VDD B2=n3963
+ VSS=VSS
XU2689 MAOI22D1BWP7T $PINS A2=n2020 ZN=n2023 A1=p<13> B2=p<13> VDD=VDD B1=n2020
+ VSS=VSS
XU2679 INVD0BWP7T $PINS ZN=n2010 VSS=VSS VDD=VDD I=p<10>
XU2676 MAOI22D1BWP7T $PINS A2=n2007 ZN=n2009 A1=n3711 B2=n3711 VDD=VDD B1=n2007
+ VSS=VSS
XU2671 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2002 A1=k<7> VDD=VDD B2=n2453
+ VSS=VSS
XU2668 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n1999 A1=n4391 VDD=VDD
+ B2=rout<6> VSS=VSS
XU2666 INVD1BWP7T $PINS ZN=n1998 VSS=VSS VDD=VDD I=p<6>
XU2664 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n1996 A1=n4390 VDD=VDD B2=n3884
+ VSS=VSS
XU2663 MAOI22D1BWP7T $PINS A2=n3795 ZN=n1997 A1=n3710 B2=n3710 VDD=VDD B1=n3795
+ VSS=VSS
XU2657 MAOI22D1BWP7T $PINS A2=n3793 ZN=n1991 A1=n3709 B2=n3709 VDD=VDD B1=n3793
+ VSS=VSS
XU2656 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1987 A1=n3995 ZN=N100 A2=n1988
XU2655 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n1987 A1=n4456 VDD=VDD B2=n3886
+ VSS=VSS
XU2653 IAO22D1BWP7T $PINS A2=p<3> ZN=n1988 A1=n1985 B2=n1985 VDD=VDD B1=p<3>
+ VSS=VSS
XU2650 MAOI22D1BWP7T $PINS A2=n1982 ZN=n1984 A1=n3708 B2=n3708 VDD=VDD B1=n1982
+ VSS=VSS
XU2644 MAOI22D2BWP7T $PINS A2=p<1> ZN=n1979 A1=n3790 B2=n3790 VDD=VDD B1=p<1>
+ VSS=VSS
XU2642 AOI22D2BWP7T $PINS B1=n3949 A2=n1975 ZN=n1976 A1=n3994 VDD=VDD B2=n4049
+ VSS=VSS
XU2639 OAI211D2BWP7T $PINS A2=n3982 ZN=rk0<31> A1=n1973 B=n4433 VDD=VDD C=n1970
+ VSS=VSS
XU2638 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1967 A2=n1968 A1=n3999 ZN=n1971
+ C=n1966
XU2637 AOI21D0BWP7T $PINS VSS=VSS A2=n1968 VDD=VDD A1=n3788 B=n1965 ZN=n1966
XU2636 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3788 ZN=n1965 A2=n1968
XU2635 AOI21D0BWP7T $PINS VSS=VSS A2=n4092 VDD=VDD A1=n3843 B=n1962 ZN=n1967
XU2634 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3843 ZN=n1962 A2=n4092
XU2630 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<30> A1=n1958 B=n1956 VDD=VDD C=n1955
+ VSS=VSS
XU2629 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1953 A1=n3786 ZN=n1955 A2=n4068
XU2628 AOI21D0BWP7T $PINS VSS=VSS A2=n4068 VDD=VDD A1=n3786 B=n4016 ZN=n1953
XU2624 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3643 A1=n3842 ZN=n1947 A2=n1950
XU2620 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1940 A2=n1941 A1=n3999 ZN=n1943
+ C=n1939
XU2619 AOI21D0BWP7T $PINS VSS=VSS A2=n4095 VDD=VDD A1=n3841 B=n1937 ZN=n1939
XU2618 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3841 ZN=n1937 A2=n4095
XU2616 AOI21D1BWP7T $PINS VSS=VSS A2=n1941 VDD=VDD A1=n3784 B=n1936 ZN=n1940
XU2615 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3784 ZN=n1936 A2=n1941
XU2611 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<28> A1=n1933 B=n1931 VDD=VDD C=n1930
+ VSS=VSS
XU2610 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1928 A1=n4396 ZN=n1930 A2=n1929
XU2609 AOI21D0BWP7T $PINS VSS=VSS A2=n1929 VDD=VDD A1=k<124> B=n4021 ZN=n1928
XU2608 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1925 A2=n1929 A1=n3983 ZN=n1931
+ C=n1924
XU2607 AOI21D0BWP7T $PINS VSS=VSS A2=n2665 VDD=VDD A1=k<60> B=n1922 ZN=n1924
XU2606 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<60> ZN=n1922 A2=n2665
XU2602 OAI211D1BWP7T $PINS A2=n4000 ZN=rk0<27> A1=n1918 B=n1917 VDD=VDD C=n1916
+ VSS=VSS
XU2601 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1914 A1=n3782 ZN=n1916 A2=n4085
XU2600 AOI21D0BWP7T $PINS VSS=VSS A2=n4085 VDD=VDD A1=n3782 B=n4016 ZN=n1914
XU2598 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1912 A2=n1913 A1=n3985 ZN=n1917
+ C=n1911
XU2597 AOI21D0BWP7T $PINS VSS=VSS A2=n1913 VDD=VDD A1=n3840 B=n1910 ZN=n1911
XU2593 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<26> A1=n1907 B=n1906 VDD=VDD C=n1905
+ VSS=VSS
XU2592 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1903 A1=n3780 ZN=n1905 A2=n4066
XU2591 AOI21D0BWP7T $PINS VSS=VSS A2=n4066 VDD=VDD A1=n3780 B=n4016 ZN=n1903
XU2589 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1901 A2=n1902 A1=n3983 ZN=n1906
+ C=n1900
XU2588 AOI21D0BWP7T $PINS VSS=VSS A2=n1902 VDD=VDD A1=n3839 B=n1899 ZN=n1900
XU2587 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3839 ZN=n1899 A2=n1902
XU2584 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<25> A1=n4434 B=n1895 VDD=VDD C=n1894
+ VSS=VSS
XU2583 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1892 A1=k<121> ZN=n1894 A2=n1893
XU2582 AOI21D0BWP7T $PINS VSS=VSS A2=n1893 VDD=VDD A1=k<121> B=n4021 ZN=n1892
XU2581 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1890 A2=n1893 A1=n3983 ZN=n1895
+ C=n1889
XU2580 AOI21D0BWP7T $PINS VSS=VSS A2=n4104 VDD=VDD A1=k<57> B=n1887 ZN=n1889
XU2579 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<57> ZN=n1887 A2=n4104
XU2575 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<24> A1=n1883 B=n1882 VDD=VDD C=n1881
+ VSS=VSS
XU2574 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1879 A1=n3838 ZN=n1881 A2=n1880
XU2573 AOI21D0BWP7T $PINS VSS=VSS A2=n1880 VDD=VDD A1=n3838 B=n4021 ZN=n1879
XU2572 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1878 A2=n1880 A1=n3983 ZN=n1882
+ C=n1877
XU2571 AOI21D1BWP7T $PINS VSS=VSS A2=n4084 VDD=VDD A1=n3778 B=n1875 ZN=n1877
XU2570 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3778 ZN=n1875 A2=n4084
XU2565 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<23> A1=n1871 B=n1870 VDD=VDD C=n1869
+ VSS=VSS
XU2564 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1867 A1=n3837 ZN=n1869 A2=n1868
XU2562 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1866 A2=n1868 A1=n3983 ZN=n1870
+ C=n1865
XU2561 AOI21D0BWP7T $PINS VSS=VSS A2=n4082 VDD=VDD A1=n3776 B=n1863 ZN=n1865
XU2560 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3776 ZN=n1863 A2=n4082
XU2556 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<22> A1=n1860 B=n1859 VDD=VDD C=n1858
+ VSS=VSS
XU2555 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1856 A1=k<118> ZN=n1858 A2=n1857
XU2554 AOI21D0BWP7T $PINS VSS=VSS A2=n1857 VDD=VDD A1=k<118> B=n4021 ZN=n1856
XU2553 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1855 A2=n1857 A1=n3983 ZN=n1859
+ C=n1854
XU2552 AOI21D0BWP7T $PINS VSS=VSS A2=n4105 VDD=VDD A1=n3774 B=n1852 ZN=n1854
XU2551 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3774 ZN=n1852 A2=n4105
XU2547 OAI211D1BWP7T $PINS A2=n3998 ZN=rk0<21> A1=n1849 B=n1848 VDD=VDD C=n1847
+ VSS=VSS
XU2546 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1845 A1=k<53> ZN=n1847 A2=n4088
XU2545 AOI21D0BWP7T $PINS VSS=VSS A2=n4088 VDD=VDD A1=k<53> B=n4016 ZN=n1845
XU2543 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1843 A2=n1844 A1=n3983 ZN=n1848
+ C=n1842
XU2542 AOI21D0BWP7T $PINS VSS=VSS A2=n1844 VDD=VDD A1=n3836 B=n1841 ZN=n1842
XU2541 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3836 ZN=n1841 A2=n1844
XU2537 OAI211D1BWP7T $PINS A2=n4000 ZN=rk0<20> A1=n1837 B=n1836 VDD=VDD C=n1835
+ VSS=VSS
XU2536 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1833 A1=n3835 ZN=n1835 A2=n1834
XU2535 AOI21D0BWP7T $PINS VSS=VSS A2=n1834 VDD=VDD A1=n3835 B=n4021 ZN=n1833
XU2534 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1832 A2=n1834 A1=n3985 ZN=n1836
+ C=n1831
XU2533 AOI21D0BWP7T $PINS VSS=VSS A2=n4096 VDD=VDD A1=k<52> B=n1829 ZN=n1831
XU2532 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=k<52> ZN=n1829 A2=n4096
XU2527 AOI211D1BWP7T $PINS VSS=VSS VDD=VDD B=n1822 A2=n1823 A1=n3999 ZN=n1825
+ C=n1821
XU2526 AOI21D0BWP7T $PINS VSS=VSS A2=n1823 VDD=VDD A1=n3772 B=n1820 ZN=n1821
XU2525 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4017 A1=n3772 ZN=n1820 A2=n1823
XU2524 AOI21D0BWP7T $PINS VSS=VSS A2=n4080 VDD=VDD A1=n3834 B=n1818 ZN=n1822
XU2869 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2143 ZN=N187 A2=n3989 A1=n2144
XU2867 MAOI22D0BWP7T $PINS A2=p<90> ZN=n2144 A1=n3839 B2=p<90> VDD=VDD B1=n3839
+ VSS=VSS
XU2866 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2141 ZN=N186 A2=n3989 A1=n2142
XU2865 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2141 A1=k<89> VDD=VDD
+ B2=rin<57> VSS=VSS
XU2862 MAOI22D0BWP7T $PINS A2=p<89> ZN=n2142 A1=n4395 B2=p<89> VDD=VDD B1=n4395
+ VSS=VSS
XU2861 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2138 ZN=N185 A2=n3989 A1=n2139
XU2860 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2138 A1=n4386 VDD=VDD B2=n3899
+ VSS=VSS
XU2858 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2135 ZN=N184 A2=n3987 A1=n2136
XU2857 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2135 A1=n4310 VDD=VDD B2=n3901
+ VSS=VSS
XU2855 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2133 ZN=N183 A2=n3989 A1=n2134
XU2854 AOI22D1BWP7T $PINS B1=n4051 A2=n4015 ZN=n2133 A1=n4385 VDD=VDD
+ B2=rin<54> VSS=VSS
XU2853 MAOI22D0BWP7T $PINS A2=p<86> ZN=n2134 A1=n4394 B2=p<86> VDD=VDD B1=n4394
+ VSS=VSS
XU2852 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2131 ZN=N182 A2=n3989 A1=n2132
XU2849 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4278 ZN=N181 A2=n3989 A1=n2130
XU2848 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2129 A1=n3804 VDD=VDD
+ B2=rout<84> VSS=VSS
XU2847 MAOI22D0BWP7T $PINS A2=p<84> ZN=n2130 A1=n3835 B2=p<84> VDD=VDD B1=n3835
+ VSS=VSS
XU2846 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4077 ZN=N180 A2=n3989 A1=n2128
XU2845 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2127 A1=n3803 VDD=VDD
+ B2=rout<83> VSS=VSS
XU2844 MAOI22D0BWP7T $PINS A2=p<83> ZN=n2128 A1=n3834 B2=p<83> VDD=VDD B1=n3834
+ VSS=VSS
XU2843 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4332 ZN=N179 A2=n3989 A1=n2126
XU2842 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2125 A1=k<82> VDD=VDD B2=n3907
+ VSS=VSS
XU2841 MAOI22D0BWP7T $PINS A2=p<82> ZN=n2126 A1=n3833 B2=p<82> VDD=VDD B1=n3833
+ VSS=VSS
XU2838 MAOI22D0BWP7T $PINS A2=p<81> ZN=n2124 A1=n3832 B2=p<81> VDD=VDD B1=n3832
+ VSS=VSS
XU2837 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4279 ZN=N177 A2=n3989 A1=n2122
XU2836 AOI22D0BWP7T $PINS B1=n4049 A2=n4014 ZN=n2121 A1=n3801 VDD=VDD
+ B2=rin<48> VSS=VSS
XU2835 MAOI22D0BWP7T $PINS A2=p<80> ZN=n2122 A1=n3831 B2=p<80> VDD=VDD B1=n3831
+ VSS=VSS
XU2834 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2119 ZN=N176 A2=n3989 A1=n2120
XU2831 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4363 ZN=N174 A2=n3989 A1=n2118
XU2828 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2115 ZN=N173 A2=n3987 A1=n2116
XU2825 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2113 ZN=N171 A2=n3989 A1=n2114
XU2822 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2110 ZN=N170 A2=n3987 A1=n2111
XU2819 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2108 ZN=N169 A2=n3987 A1=n2109
XU2816 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2106 ZN=N168 A2=n3989 A1=n2107
XU2814 MAOI22D0BWP7T $PINS A2=p<71> ZN=n2107 A1=n3822 B2=p<71> VDD=VDD B1=n3822
+ VSS=VSS
XU2810 INVD1BWP7T $PINS ZN=n2102 VSS=VSS VDD=VDD I=p<70>
XU2804 MAOI22D0BWP7T $PINS A2=n3818 ZN=n2098 A1=p<68> B2=p<68> VDD=VDD B1=n3818
+ VSS=VSS
XU2802 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2094 A1=n4382 VDD=VDD B2=n3917
+ VSS=VSS
XU2799 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4362 A1=n3990 ZN=N163 A2=n2091
XU2798 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2090 A1=n4453 VDD=VDD B2=n3918
+ VSS=VSS
XU2797 MAOI22D0BWP7T $PINS A2=n3814 ZN=n2091 A1=p<66> B2=p<66> VDD=VDD B1=n3814
+ VSS=VSS
XU2793 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4277 ZN=N161 A2=n3989 A1=n2085
XU2791 MAOI22D1BWP7T $PINS A2=p<64> ZN=n2085 A1=n3810 B2=p<64> VDD=VDD B1=n3810
+ VSS=VSS
XU2790 AO222D0BWP7T $PINS Z=N160 C2=n4051 C1=n4262 B1=n4015 A2=p<63> A1=n3989
+ VDD=VDD B2=n3788 VSS=VSS
XU2789 AO222D0BWP7T $PINS Z=N159 C2=n4051 C1=rout<62> B1=n4015 A2=p<62>
+ A1=n3989 VDD=VDD B2=n3786 VSS=VSS
XU2788 AO222D0BWP7T $PINS Z=N158 C2=n4051 C1=rout<61> B1=n4015 A2=p<61>
+ A1=n3989 VDD=VDD B2=n3784 VSS=VSS
XU2787 AO222D0BWP7T $PINS Z=N157 C2=n4051 C1=rout<60> B1=n4015 A2=p<60>
+ A1=n3989 VDD=VDD B2=n4401 VSS=VSS
XU2785 AO222D0BWP7T $PINS Z=N156 C2=n4050 C1=rout<59> B1=n4012 A2=p<59>
+ A1=n3996 VDD=VDD B2=n3782 VSS=VSS
XU2784 AO222D0BWP7T $PINS Z=N155 C2=n4049 C1=n3033 B1=n4014 A2=n3721 A1=n3994
+ VDD=VDD B2=n3780 VSS=VSS
XU2783 AO222D0BWP7T $PINS Z=N154 C2=n4050 C1=n4465 B1=n4012 A2=p<57> A1=n3996
+ VDD=VDD B2=n4459 VSS=VSS
XU2782 AO222D0BWP7T $PINS Z=N153 C2=n4051 C1=rout<56> B1=n4015 A2=p<56>
+ A1=n3989 VDD=VDD B2=n3778 VSS=VSS
XU2781 AO222D0BWP7T $PINS Z=N152 C2=n4049 C1=n3003 B1=n4014 A2=n3720 A1=n3992
+ VDD=VDD B2=n3776 VSS=VSS
XU2780 AO222D0BWP7T $PINS Z=N151 C2=n4051 C1=n4356 B1=n4015 A2=p<54> A1=n3989
+ VDD=VDD B2=n3774 VSS=VSS
XU2779 AO222D0BWP7T $PINS Z=N150 C2=n4050 C1=rout<53> B1=n4012 A2=p<53>
+ A1=n3996 VDD=VDD B2=k<53> VSS=VSS
XU2778 AO222D1BWP7T $PINS Z=N149 C2=n4049 C1=rout<52> B1=n4014 A2=n4300
+ A1=n3994 VDD=VDD B2=n4400 VSS=VSS
XU2777 AO222D1BWP7T $PINS Z=N148 C2=n4049 C1=n3009 B1=n4014 A2=n4299 A1=n3994
+ VDD=VDD B2=n3772 VSS=VSS
XU2776 AO222D0BWP7T $PINS Z=N147 C2=n4050 C1=rout<50> B1=n4012 A2=p<50>
+ A1=n3996 VDD=VDD B2=n4399 VSS=VSS
XU2775 AO222D0BWP7T $PINS Z=N146 C2=n4049 C1=rout<49> B1=n4014 A2=n3719
+ A1=n3994 VDD=VDD B2=n3471 VSS=VSS
XU2774 AO222D0BWP7T $PINS Z=N145 C2=n4049 C1=rout<48> B1=n4014 A2=n3718
+ A1=n3994 VDD=VDD B2=n3770 VSS=VSS
XU2773 AO222D0BWP7T $PINS Z=N144 C2=n4051 C1=n3042 B1=n4015 A2=p<47> A1=n3987
+ VDD=VDD B2=n3768 VSS=VSS
XU2770 AO222D0BWP7T $PINS Z=N143 C2=n4050 C1=rout<46> B1=n4012 A2=p<46>
+ A1=n3996 VDD=VDD B2=n4458 VSS=VSS
XU2769 AO222D0BWP7T $PINS Z=N142 C2=n4050 C1=rout<45> B1=n4012 A2=p<45>
+ A1=n3996 VDD=VDD B2=n4398 VSS=VSS
XU2767 AO222D0BWP7T $PINS Z=N141 C2=n4049 C1=rout<44> B1=n4014 A2=n3717
+ A1=n3992 VDD=VDD B2=n3766 VSS=VSS
XU2766 AO222D0BWP7T $PINS Z=N140 C2=n4050 C1=rout<43> B1=n4012 A2=n4448
+ A1=n3987 VDD=VDD B2=n3764 VSS=VSS
XU2765 AO222D0BWP7T $PINS Z=N139 C2=n4051 C1=n4119 B1=n4015 A2=p<42> A1=n3996
+ VDD=VDD B2=n4320 VSS=VSS
XU2764 AO222D0BWP7T $PINS Z=N138 C2=n4050 C1=n3029 B1=n4012 A2=n4447 A1=n3987
+ VDD=VDD B2=n3762 VSS=VSS
XU2763 AO222D0BWP7T $PINS Z=N137 C2=n4049 C1=n4260 B1=n4014 A2=n4298 A1=n3987
+ VDD=VDD B2=n4393 VSS=VSS
XU2762 AO222D0BWP7T $PINS Z=N136 C2=n4050 C1=rout<39> B1=n4012 A2=p<39>
+ A1=n3996 VDD=VDD B2=k<39> VSS=VSS
XU2761 AO222D1BWP7T $PINS Z=N135 C2=n4049 C1=rout<38> B1=n4014 A2=n3716
+ A1=n3994 VDD=VDD B2=k<38> VSS=VSS
XU2760 AO222D1BWP7T $PINS Z=N134 C2=n4049 C1=rout<37> B1=n4014 A2=n4297
+ A1=n3994 VDD=VDD B2=k<37> VSS=VSS
XU2759 AO222D1BWP7T $PINS Z=N133 C2=n4049 C1=rout<36> B1=n4014 A2=n3715
+ A1=n3994 VDD=VDD B2=k<36> VSS=VSS
XU2756 AO222D1BWP7T $PINS Z=N132 C2=n4049 C1=rout<35> B1=n4014 A2=n4376
+ A1=n3994 VDD=VDD B2=k<35> VSS=VSS
XU2755 AO222D1BWP7T $PINS Z=N131 C2=n4049 C1=rout<34> B1=n4014 A2=n3714
+ A1=n3994 VDD=VDD B2=n4304 VSS=VSS
XU2753 AO222D1BWP7T $PINS Z=N130 C2=n4049 C1=rout<33> B1=n4014 A2=n3713
+ A1=n3994 VDD=VDD B2=n3754 VSS=VSS
XU2746 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2069 ZN=N126 A2=n3987 A1=n2070
XU2745 AOI22D0BWP7T $PINS B1=n4051 A2=n4015 ZN=n2069 A1=n3748 VDD=VDD
+ B2=rin<125> VSS=VSS
XU2744 MAOI22D0BWP7T $PINS A2=p<29> ZN=n2070 A1=n3807 B2=p<29> VDD=VDD B1=n3807
+ VSS=VSS
XU2742 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2067 A1=n4377 VDD=VDD
+ B2=rin<124> VSS=VSS
XU2736 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2060 ZN=N123 A2=n3987 A1=n2061
XU2735 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2060 A1=n3744 VDD=VDD B2=n3923
+ VSS=VSS
XU2720 IOA21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2043 ZN=N118 A2=n3996 A1=n2044
XU2719 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2043 A1=n3736 VDD=VDD
+ B2=rout<21> VSS=VSS
XU2718 MAOI22D0BWP7T $PINS A2=p<21> ZN=n2044 A1=n3805 B2=p<21> VDD=VDD B1=n3805
+ VSS=VSS
XU2717 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4079 ZN=N117 A2=n3987 A1=n2042
XU2716 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2041 A1=k<20> VDD=VDD
+ B2=rout<20> VSS=VSS
XU2715 MAOI22D1BWP7T $PINS A2=p<20> ZN=n2042 A1=n3804 B2=p<20> VDD=VDD B1=n3804
+ VSS=VSS
XU2714 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2038 ZN=N116 A2=n3992 A1=n2039
XU2713 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2038 A1=n3734 VDD=VDD B2=n3931
+ VSS=VSS
XU2711 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2036 ZN=N115 A2=n3996 A1=n2037
XU2710 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2036 A1=n4319 VDD=VDD B2=n3933
+ VSS=VSS
XU2709 MAOI22D1BWP7T $PINS A2=p<18> ZN=n2037 A1=n4328 B2=p<18> VDD=VDD B1=n4328
+ VSS=VSS
XU2708 IOA21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2034 ZN=N114 A2=n3994 A1=n2035
XU1494 INVD0BWP7T $PINS ZN=n2414 VSS=VSS VDD=VDD I=k<17>
XU3087 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n3986 A1=round<2> ZN=n1040 A2=n3979
XU3086 AOI21D0BWP7T $PINS VSS=VSS A2=n3986 VDD=VDD A1=round<3> B=n2308 ZN=n1041
XU3085 OAI211D0BWP7T $PINS A2=n2307 ZN=n1042 A1=n3853 B=n3630 VDD=VDD C=n2489
+ VSS=VSS
XU3076 AO222D0BWP7T $PINS Z=n1051 C2=n3994 C1=n4262 B1=l<31> A2=l<38> A1=n4056
+ VDD=VDD B2=n3856 VSS=VSS
XU3075 AO222D0BWP7T $PINS Z=n1052 C2=n3994 C1=rout<70> B1=l<45> A2=l<38>
+ A1=n3856 VDD=VDD B2=n4056 VSS=VSS
XU3069 AO222D0BWP7T $PINS Z=n1058 C2=n3994 C1=n3963 B1=l<102> A2=l<109>
+ A1=n3856 VDD=VDD B2=n4056 VSS=VSS
XU3068 AO222D0BWP7T $PINS Z=n1059 C2=n3994 C1=rout<6> B1=l<95> A2=l<102>
+ A1=n3856 VDD=VDD B2=n4056 VSS=VSS
XU3066 AO222D0BWP7T $PINS Z=n1061 C2=n3987 C1=rout<119> B1=n3880 A2=n3875
+ A1=n4053 VDD=VDD B2=n3855 VSS=VSS
XU3060 AO222D0BWP7T $PINS Z=n1067 C2=n3992 C1=rout<48> B1=l<16> A2=l<23>
+ A1=n4053 VDD=VDD B2=n3855 VSS=VSS
XU3059 AO222D0BWP7T $PINS Z=n1068 C2=n3992 C1=n3003 B1=l<30> A2=l<23> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3058 AO222D0BWP7T $PINS Z=n1069 C2=n3987 C1=rout<62> B1=n4463 A2=l<30>
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU3057 AO222D0BWP7T $PINS Z=n1070 C2=n3992 C1=n3915 B1=l<44> A2=n4463 A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3049 AO222D0BWP7T $PINS Z=n1076 C2=n3987 C1=n3939 B1=l<101> A2=l<108>
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU3048 AO222D0BWP7T $PINS Z=n1077 C2=n3987 C1=n3884 B1=l<94> A2=l<101> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3037 AO222D0BWP7T $PINS Z=n1087 C2=n3992 C1=rout<61> B1=l<29> A2=n3881
+ A1=n4053 VDD=VDD B2=n3856 VSS=VSS
XU3036 AO222D0BWP7T $PINS Z=n1088 C2=n3994 C1=n3916 B1=l<43> A2=n3881 A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3035 AO222D0BWP7T $PINS Z=n1089 C2=n3994 C1=n3913 B1=n3863 A2=l<43> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3031 AO222D0BWP7T $PINS Z=n1093 C2=n3994 C1=n3933 B1=l<107> A2=l<114>
+ A1=n3856 VDD=VDD B2=n4056 VSS=VSS
XU3030 AO222D0BWP7T $PINS Z=n1094 C2=n3987 C1=n3958 B1=l<100> A2=l<107>
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU3029 AO222D0BWP7T $PINS Z=n1095 C2=n3987 C1=n3885 B1=l<93> A2=l<100> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU3024 AO222D0BWP7T $PINS Z=n1097 C2=n3987 C1=rout<39> B1=l<7> A2=l<14>
+ A1=n4053 VDD=VDD B2=n3856 VSS=VSS
XU3023 AO222D0BWP7T $PINS Z=n1098 C2=n3987 C1=rout<46> B1=l<14> A2=n3869
+ A1=n4053 VDD=VDD B2=n3856 VSS=VSS
XU3022 AO222D0BWP7T $PINS Z=n1099 C2=n3987 C1=rout<53> B1=n3869 A2=l<28>
+ A1=n4053 VDD=VDD B2=n3856 VSS=VSS
XU3021 AO222D0BWP7T $PINS Z=n1100 C2=n3987 C1=rout<60> B1=l<35> A2=l<28>
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU3020 AO222D0BWP7T $PINS Z=n1101 C2=n3987 C1=n3917 B1=l<42> A2=l<35> A1=n3856
+ VDD=VDD B2=n4056 VSS=VSS
XU3011 AO222D0BWP7T $PINS Z=n1109 C2=n3987 C1=n3940 B1=l<99> A2=l<106> A1=n3856
+ VDD=VDD B2=n4056 VSS=VSS
XU3010 AO222D0BWP7T $PINS Z=n1110 C2=n3987 C1=n3886 B1=l<92> A2=l<99> A1=n3856
+ VDD=VDD B2=n4056 VSS=VSS
XU3009 AO222D0BWP7T $PINS Z=n1111 C2=n3987 C1=rout<124> B1=l<92> A2=l<85>
+ A1=n4056 VDD=VDD B2=n3856 VSS=VSS
XU3002 AO222D1BWP7T $PINS Z=n1117 C2=n3992 C1=rout<52> B1=n3879 A2=l<27>
+ A1=n4053 VDD=VDD B2=n3855 VSS=VSS
XU3001 AO222D0BWP7T $PINS Z=n1118 C2=n3992 C1=rout<59> B1=l<34> A2=l<27>
+ A1=n3858 VDD=VDD B2=n4053 VSS=VSS
XU3000 AO222D0BWP7T $PINS Z=n1119 C2=n3992 C1=n3918 B1=l<41> A2=l<34> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU2990 AO222D0BWP7T $PINS Z=n1127 C2=n3992 C1=n3953 B1=l<98> A2=l<105> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU2989 AO222D0BWP7T $PINS Z=n1128 C2=n3992 C1=n3887 B1=l<91> A2=l<98> A1=n3856
+ VDD=VDD B2=n4053 VSS=VSS
XU2987 AO222D0BWP7T $PINS Z=n1129 C2=n3994 C1=n4161 B1=l<91> A2=l<84> A1=n4056
+ VDD=VDD B2=n3856 VSS=VSS
XU2979 AO222D0BWP7T $PINS Z=n1136 C2=n3992 C1=n3033 B1=l<26> A2=l<33> A1=n4053
+ VDD=VDD B2=n3855 VSS=VSS
XU2978 AO222D0BWP7T $PINS Z=n1137 C2=n3992 C1=n3868 B1=l<40> A2=l<33> A1=n3855
+ VDD=VDD B2=n4053 VSS=VSS
XU2965 AO222D0BWP7T $PINS Z=n1145 C2=n3992 C1=n3941 B1=l<97> A2=l<104> A1=n3855
+ VDD=VDD B2=n4053 VSS=VSS
XU2964 AO222D0BWP7T $PINS Z=n1146 C2=n3992 C1=n3888 B1=l<90> A2=l<97> A1=n3855
+ VDD=VDD B2=n4053 VSS=VSS
XU2949 AO222D0BWP7T $PINS Z=n1156 C2=n3994 C1=n3914 B1=l<46> A2=l<39> A1=n3855
+ VDD=VDD B2=n4056 VSS=VSS
XU2948 AO222D0BWP7T $PINS Z=n1157 C2=n3994 C1=n3910 B1=l<53> A2=l<46> A1=n3855
+ VDD=VDD B2=n4056 VSS=VSS
XU2943 AO222D0BWP7T $PINS Z=n1161 C2=n3996 C1=rout<21> B1=l<110> A2=l<117>
+ A1=n3855 VDD=VDD B2=n4056 VSS=VSS
XU2942 AO222D0BWP7T $PINS Z=n1162 C2=n3996 C1=n3938 B1=l<103> A2=l<110>
+ A1=n3855 VDD=VDD B2=n4056 VSS=VSS
XU2935 AO222D0BWP7T $PINS Z=n1166 C2=n3987 C1=rout<117> B1=l<85> A2=l<78>
+ A1=n4053 VDD=VDD B2=n3856 VSS=VSS
XU2931 AO222D0BWP7T $PINS Z=n1167 C2=n3987 C1=rout<110> B1=n3872 A2=l<78>
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU2930 AO222D0BWP7T $PINS Z=n1168 C2=n3987 C1=rout<103> B1=n3873 A2=n3872
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU2928 AO222D0BWP7T $PINS Z=n1169 C2=n3987 C1=rout<96> B1=n3874 A2=n3873
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU2927 AO222D0BWP7T $PINS Z=n1170 C2=n3992 C1=rout<32> B1=l<7> A2=n3874
+ A1=n3856 VDD=VDD B2=n4053 VSS=VSS
XU2921 AO222D0BWP7T $PINS Z=N224 C2=n4051 C1=rout<127> B1=n4015 A2=p<127>
+ A1=n3989 VDD=VDD B2=n3843 VSS=VSS
XU2920 AO222D0BWP7T $PINS Z=N223 C2=n4051 C1=n3251 B1=n4015 A2=p<126> A1=n3989
+ VDD=VDD B2=n3842 VSS=VSS
XU2919 AO222D0BWP7T $PINS Z=N222 C2=n4051 C1=n2873 B1=n4015 A2=p<125> A1=n3989
+ VDD=VDD B2=n3841 VSS=VSS
XU2918 AO222D0BWP7T $PINS Z=N221 C2=n4051 C1=rout<124> B1=n4015 A2=p<124>
+ A1=n3989 VDD=VDD B2=n4396 VSS=VSS
XU2915 AO222D0BWP7T $PINS Z=N220 C2=n4051 C1=n4161 B1=n4015 A2=p<123> A1=n3989
+ VDD=VDD B2=n3840 VSS=VSS
XU2914 AO222D0BWP7T $PINS Z=N219 C2=n4051 C1=rout<122> B1=n4015 A2=p<122>
+ A1=n3989 VDD=VDD B2=n3839 VSS=VSS
XU2913 AO222D0BWP7T $PINS Z=N218 C2=n4051 C1=rout<121> B1=n4015 A2=p<121>
+ A1=n3989 VDD=VDD B2=n4395 VSS=VSS
XU2912 AO222D0BWP7T $PINS Z=N217 C2=n4051 C1=rout<120> B1=n4015 A2=p<120>
+ A1=n3989 VDD=VDD B2=n3838 VSS=VSS
XU2911 AO222D1BWP7T $PINS Z=N216 C2=n4051 C1=n4429 B1=n4015 A2=p<119> A1=n3989
+ VDD=VDD B2=n3837 VSS=VSS
XU2910 AO222D0BWP7T $PINS Z=N215 C2=n4051 C1=rout<118> B1=n4015 A2=p<118>
+ A1=n3989 VDD=VDD B2=n4394 VSS=VSS
XU2908 AO222D0BWP7T $PINS Z=N213 C2=n4050 C1=rout<116> B1=n4012 A2=p<116>
+ A1=n3996 VDD=VDD B2=n3835 VSS=VSS
XU2907 AO222D0BWP7T $PINS Z=N212 C2=n4051 C1=n4140 B1=n4015 A2=p<115> A1=n3989
+ VDD=VDD B2=n3834 VSS=VSS
XU2906 AO222D0BWP7T $PINS Z=N211 C2=n4051 C1=n4164 B1=n4015 A2=p<114> A1=n3989
+ VDD=VDD B2=n3833 VSS=VSS
XU2905 AO222D0BWP7T $PINS Z=N210 C2=n4051 C1=rout<113> B1=n4015 A2=p<113>
+ A1=n3989 VDD=VDD B2=n3832 VSS=VSS
XU2904 AO222D0BWP7T $PINS Z=N209 C2=n4051 C1=rout<112> B1=n4015 A2=p<112>
+ A1=n3989 VDD=VDD B2=n3831 VSS=VSS
XU2903 AO222D0BWP7T $PINS Z=N208 C2=n4051 C1=rout<111> B1=n4015 A2=p<111>
+ A1=n3989 VDD=VDD B2=n3830 VSS=VSS
XU2902 AO222D0BWP7T $PINS Z=N207 C2=n4051 C1=rout<110> B1=n4015 A2=p<110>
+ A1=n3989 VDD=VDD B2=n4389 VSS=VSS
XU2901 AO222D0BWP7T $PINS Z=N206 C2=n4051 C1=rout<109> B1=n4015 A2=p<109>
+ A1=n3989 VDD=VDD B2=n4334 VSS=VSS
XU2900 AO222D0BWP7T $PINS Z=N205 C2=n4051 C1=rout<108> B1=n4015 A2=p<108>
+ A1=n3989 VDD=VDD B2=n3828 VSS=VSS
XU2899 AO222D0BWP7T $PINS Z=N204 C2=n4051 C1=n4168 B1=n4015 A2=p<107> A1=n3989
+ VDD=VDD B2=n3826 VSS=VSS
XU2898 AO222D0BWP7T $PINS Z=N203 C2=n4051 C1=n4142 B1=n4015 A2=p<106> A1=n3989
+ VDD=VDD B2=n3825 VSS=VSS
XU2896 AO222D0BWP7T $PINS Z=N202 C2=n4051 C1=rout<105> B1=n4015 A2=p<105>
+ A1=n3987 VDD=VDD B2=n3824 VSS=VSS
XU2895 AO222D0BWP7T $PINS Z=N201 C2=n4051 C1=rout<104> B1=n4015 A2=p<104>
+ A1=n3987 VDD=VDD B2=n3823 VSS=VSS
XU2894 AO222D0BWP7T $PINS Z=N200 C2=n4051 C1=rout<103> B1=n4015 A2=p<103>
+ A1=n3989 VDD=VDD B2=n3822 VSS=VSS
XU2893 AO222D0BWP7T $PINS Z=N199 C2=n4051 C1=rout<102> B1=n4015 A2=p<102>
+ A1=n3989 VDD=VDD B2=n3821 VSS=VSS
XU2892 AO222D0BWP7T $PINS Z=N198 C2=n4051 C1=rout<101> B1=n4015 A2=p<101>
+ A1=n3987 VDD=VDD B2=n3819 VSS=VSS
XU2891 AO222D0BWP7T $PINS Z=N197 C2=n4051 C1=rout<100> B1=n4015 A2=p<100>
+ A1=n3987 VDD=VDD B2=n3817 VSS=VSS
XU2890 AO222D0BWP7T $PINS Z=N196 C2=n4051 C1=rout<99> B1=n4015 A2=p<99>
+ A1=n3989 VDD=VDD B2=n3815 VSS=VSS
XU2889 AO222D0BWP7T $PINS Z=N195 C2=n4051 C1=rout<98> B1=n4015 A2=p<98>
+ A1=n3987 VDD=VDD B2=n3813 VSS=VSS
XU2887 AO222D0BWP7T $PINS Z=N194 C2=n4049 C1=n2983 B1=n4014 A2=n3722 A1=n3987
+ VDD=VDD B2=n3811 VSS=VSS
XU2886 AO222D0BWP7T $PINS Z=N193 C2=n4051 C1=rout<96> B1=n4015 A2=p<96>
+ A1=n3989 VDD=VDD B2=n3810 VSS=VSS
XU2885 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2159 ZN=N192 A2=n3989 A1=n2161
XU2884 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2159 A1=n4388 VDD=VDD
+ B2=rin<63> VSS=VSS
XU2882 MAOI22D0BWP7T $PINS A2=p<95> ZN=n2161 A1=n3843 B2=p<95> VDD=VDD B1=n3843
+ VSS=VSS
XU2881 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2153 ZN=N191 A2=n3989 A1=n2155
XU2880 AOI22D1BWP7T $PINS B1=n4051 A2=n4015 ZN=n2153 A1=n3808 VDD=VDD B2=n3945
+ VSS=VSS
XU2878 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2149 ZN=N190 A2=n3989 A1=n2151
XU2877 AOI22D1BWP7T $PINS B1=n4051 A2=n4015 ZN=n2149 A1=n3807 VDD=VDD
+ B2=rin<61> VSS=VSS
XU2876 MAOI22D0BWP7T $PINS A2=p<93> ZN=n2151 A1=n3841 B2=p<93> VDD=VDD B1=n3841
+ VSS=VSS
XU2875 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2147 ZN=N189 A2=n3989 A1=n2148
XU2874 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2147 A1=k<92> VDD=VDD
+ B2=rin<60> VSS=VSS
XU2873 MAOI22D0BWP7T $PINS A2=p<92> ZN=n2148 A1=n4396 B2=p<92> VDD=VDD B1=n4396
+ VSS=VSS
XU2872 IOA21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2145 ZN=N188 A2=n3989 A1=n2146
XU2871 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2145 A1=n4387 VDD=VDD B2=n3895
+ VSS=VSS
XU2870 IAO22D2BWP7T $PINS A2=p<91> ZN=n2146 A1=n3840 B2=p<91> VDD=VDD B1=n3840
+ VSS=VSS
Xicc_place1715 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<22> Z=n3870
Xicc_place1731 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3886 I=rin<99>
Xicc_place1784 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3939 I=rin<108>
Xicc_place1770 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3925 I=rin<121>
Xicc_place1918 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4072 ZN=n4073
Xicc_place1906 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1772 Z=n4061
Xicc_place1712 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2354 Z=n3867
Xicc_place1740 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3895 I=rin<59>
Xicc_place1730 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3885 I=rin<100>
Xicc_place1786 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3941 I=rin<104>
Xicc_place1710 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2339 Z=n3865
Xicc_place1798 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3953 I=rin<105>
Xicc_place1729 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n3884 I=rin<101>
XU2850 MAOI22D1BWP7T $PINS A2=p<85> ZN=n2132 A1=n3836 B2=p<85> VDD=VDD B1=n3836
+ VSS=VSS
XU2856 MAOI22D2BWP7T $PINS A2=p<87> ZN=n2136 A1=n3837 B2=p<87> VDD=VDD B1=n3837
+ VSS=VSS
XU2879 MAOI22D2BWP7T $PINS A2=p<94> ZN=n2155 A1=n3842 B2=p<94> VDD=VDD B1=n3842
+ VSS=VSS
XU2641 IAO22D2BWP7T $PINS A2=n4329 ZN=n1975 A1=p<0> B2=p<0> VDD=VDD B1=n4329
+ VSS=VSS
XU2700 MAOI22D1BWP7T $PINS A2=n4338 ZN=n2033 A1=n3801 B2=n4338 VDD=VDD B1=n3801
+ VSS=VSS
XU2712 MAOI22D2BWP7T $PINS A2=p<19> ZN=n2039 A1=n3803 B2=p<19> VDD=VDD B1=n3803
+ VSS=VSS
XU3088 INVD0BWP7T $PINS ZN=n2739 VSS=VSS VDD=VDD I=n3251
XU2986 INVD1BWP7T $PINS ZN=n2727 VSS=VSS VDD=VDD I=n2983
XU2932 INVD0BWP7T $PINS ZN=n2710 VSS=VSS VDD=VDD I=n4351
XU2786 INVD0BWP7T $PINS ZN=n2696 VSS=VSS VDD=VDD I=n3003
XU2758 INVD1BWP7T $PINS ZN=n2692 VSS=VSS VDD=VDD I=n3029
XU2757 INVD0BWP7T $PINS ZN=n2691 VSS=VSS VDD=VDD I=n4260
XU2737 INVD0BWP7T $PINS ZN=n2689 VSS=VSS VDD=VDD I=rout<50>
XU2654 INVD0BWP7T $PINS ZN=n2679 VSS=VSS VDD=VDD I=n3042
XU2568 INVD0BWP7T $PINS ZN=n2665 VSS=VSS VDD=VDD I=n1933
XU2461 INVD0BWP7T $PINS ZN=n2651 VSS=VSS VDD=VDD I=n1698
XU2247 INVD0BWP7T $PINS ZN=n2635 VSS=VSS VDD=VDD I=n1475
XU2146 INVD1BWP7T $PINS ZN=n2622 VSS=VSS VDD=VDD I=n3296
XU1990 INVD0BWP7T $PINS ZN=n2610 VSS=VSS VDD=VDD I=n1570
XU1878 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3169 ZN=n2584
XU1618 INVD0BWP7T $PINS ZN=n2489 VSS=VSS VDD=VDD I=n1559
XU1505 INVD0BWP7T $PINS ZN=n2422 VSS=VSS VDD=VDD I=k<49>
XU1504 INVD0BWP7T $PINS ZN=n2421 VSS=VSS VDD=VDD I=k<45>
XU1502 INVD0BWP7T $PINS ZN=n2419 VSS=VSS VDD=VDD I=n4320
XU1501 INVD0BWP7T $PINS ZN=n2418 VSS=VSS VDD=VDD I=n4393
XU1499 INVD0BWP7T $PINS ZN=n2417 VSS=VSS VDD=VDD I=k<39>
XU1498 INVD0BWP7T $PINS ZN=n2416 VSS=VSS VDD=VDD I=k<32>
Xicc_place1744 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3899 I=rin<56>
Xicc_place1732 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3887 I=rin<98>
Xicc_place1733 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3888 I=rin<97>
Xicc_place1785 BUFFD12BWP7T $PINS VSS=VSS VDD=VDD Z=n3940 I=rin<106>
Xicc_place1808 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3963 I=rin<109>
Xicc_place1758 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3913 I=rin<43>
Xicc_place1803 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3958 I=rin<107>
XU1856 AOI22D0BWP7T $PINS B1=n4050 A2=n4012 ZN=n1276 A1=n3797 VDD=VDD B2=n3913
+ VSS=VSS
XU1850 MAOI22D1BWP7T $PINS A2=n3827 ZN=n1277 A1=p<75> B2=p<75> VDD=VDD B1=n3827
+ VSS=VSS
XU1857 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4435 A1=n3990 ZN=N172 A2=n1277
XU2811 MAOI22D1BWP7T $PINS A2=n2102 ZN=n2104 A1=n3821 B2=n3821 VDD=VDD B1=n2102
+ VSS=VSS
XU2813 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4274 A1=n3990 ZN=N167 A2=n2104
XU2794 MAOI22D0BWP7T $PINS A2=n3812 ZN=n2088 A1=p<65> B2=p<65> VDD=VDD B1=n3812
+ VSS=VSS
XU2751 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2075 A1=n3752 VDD=VDD B2=n3919
+ VSS=VSS
XU2750 IAO22D2BWP7T $PINS A2=p<31> ZN=n2076 A1=n2074 B2=n2074 VDD=VDD B1=p<31>
+ VSS=VSS
XU2747 MAOI22D1BWP7T $PINS A2=n3809 ZN=n2073 A1=p<30> B2=p<30> VDD=VDD B1=n3809
+ VSS=VSS
XU2749 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n3449 A1=n3988 ZN=N127 A2=n2073
XU2739 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2064 A1=n3746 VDD=VDD B2=n3921
+ VSS=VSS
XU2738 MAOI22D1BWP7T $PINS A2=n2063 ZN=n2065 A1=p<27> B2=p<27> VDD=VDD B1=n2063
+ VSS=VSS
XU2740 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2064 A1=n3988 ZN=N124 A2=n2065
XU2734 MAOI22D0BWP7T $PINS A2=n4333 ZN=n2061 A1=n3806 B2=n4378 VDD=VDD B1=n3806
+ VSS=VSS
XU2732 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2057 A1=n4318 VDD=VDD B2=n3925
+ VSS=VSS
XU2730 MAOI22D1BWP7T $PINS A2=n2055 ZN=n2058 A1=p<25> B2=p<25> VDD=VDD B1=n2055
+ VSS=VSS
XU2733 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2057 A1=n3997 ZN=N122 A2=n2058
XU2728 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2053 A1=n3742 VDD=VDD
+ B2=rin<120> VSS=VSS
XU2727 MAOI22D1BWP7T $PINS A2=n2051 ZN=n2054 A1=p<24> B2=p<24> VDD=VDD B1=n2051
+ VSS=VSS
XU2722 AOI22D1BWP7T $PINS B1=n4051 A2=n4015 ZN=n2046 A1=n3738 VDD=VDD
+ B2=rin<118> VSS=VSS
XU2721 MAOI22D1BWP7T $PINS A2=n2045 ZN=n2047 A1=p<22> B2=p<22> VDD=VDD B1=n2045
+ VSS=VSS
XU2723 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2046 A1=n3997 ZN=N119 A2=n2047
XU2680 MAOI22D1BWP7T $PINS A2=n2010 ZN=n2012 A1=n4460 B2=n4461 VDD=VDD B1=n2010
+ VSS=VSS
XU2677 AOI22D0BWP7T $PINS B1=n4049 A2=n4014 ZN=n2008 A1=n3244 VDD=VDD B2=n3953
+ VSS=VSS
XU2673 MAOI22D0BWP7T $PINS A2=n2004 ZN=n2006 A1=n4301 B2=n4301 VDD=VDD B1=n2004
+ VSS=VSS
XU2285 MUX2ND0BWP7T $PINS ZN=n1569 I1=n2066 I0=k<92> S=n1567 VDD=VDD VSS=VSS
XU2647 AOI22D2BWP7T $PINS B1=n4049 A2=n1979 ZN=n1980 A1=n3994 VDD=VDD B2=n3888
+ VSS=VSS
XU1496 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=round<2> A1=round<3> ZN=n1560
+ A3=n3852
XU2897 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<34> ZN=n2702
XU2108 MUX2ND1BWP7T $PINS ZN=n1417 I1=n2020 I0=k<77> S=n1415 VDD=VDD VSS=VSS
XU2658 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n1990 A1=n4379 VDD=VDD B2=n3885
+ VSS=VSS
XU3170 OAI211D0BWP7T $PINS A2=n1373 ZN=n2832 A1=n3859 B=n1372 VDD=VDD C=n4445
+ VSS=VSS
XU3117 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2399 Z=n2779
XU2667 MAOI22D1BWP7T $PINS A2=n1998 ZN=n2000 A1=n3796 B2=n3796 VDD=VDD B1=n1998
+ VSS=VSS
XU2670 MAOI22D0BWP7T $PINS A2=n2001 ZN=n2003 A1=p<7> B2=p<7> VDD=VDD B1=n2001
+ VSS=VSS
XU2807 MAOI22D0BWP7T $PINS A2=n3820 ZN=n2101 A1=p<69> B2=p<69> VDD=VDD B1=n3820
+ VSS=VSS
XU2909 AO222D0BWP7T $PINS Z=N214 C2=n4051 C1=rout<117> B1=n4015 A2=p<117>
+ A1=n3989 VDD=VDD B2=n3836 VSS=VSS
XU2291 OAI21D1BWP7T $PINS B=n1568 A2=n1569 ZN=rk1<28> VDD=VDD A1=n4021 VSS=VSS
XU2278 OAI21D1BWP7T $PINS B=n1557 A2=n1558 ZN=rk1<27> VDD=VDD A1=n4021 VSS=VSS
XU2255 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1536 A1=n4021 ZN=rk1<25> A2=n1537
XU2241 OAI21D1BWP7T $PINS B=n1525 A2=n1526 ZN=rk1<24> VDD=VDD A1=n4021 VSS=VSS
XU2114 OAI21D2BWP7T $PINS B=n1416 A2=n1417 ZN=rk1<13> VDD=VDD A1=n4021 VSS=VSS
XU2809 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4437 A1=n3990 ZN=N166 A2=n2101
XU2803 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4275 A1=n3990 ZN=N164 A2=n2095
XU2672 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4076 A1=n3988 ZN=N104 A2=n2003
XU2643 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1976 A1=n3723 ZN=N97 A2=n3630
XU2808 AOI22D0BWP7T $PINS B1=n4049 A2=n4014 ZN=n2100 A1=n3794 VDD=VDD B2=n3915
+ VSS=VSS
XU2695 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2025 A1=n3728 VDD=VDD B2=n3938
+ VSS=VSS
XU1967 OAI21D1BWP7T $PINS B=n1325 A2=n1326 ZN=rk1<3> VDD=VDD A1=n4021 VSS=VSS
XU2448 OAI22D0BWP7T $PINS B1=n1728 A2=n4016 ZN=n1730 A1=n1729 VDD=VDD B2=n3998
+ VSS=VSS
XU2430 AOI22D1BWP7T $PINS B1=n2369 A2=l<42> ZN=n1722 A1=n4064 VDD=VDD B2=n4063
+ VSS=VSS
XU2566 AOI22D2BWP7T $PINS B1=n2368 A2=l<56> ZN=n1883 A1=n4040 VDD=VDD B2=n4039
+ VSS=VSS
XU1875 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=n3318 ZN=n2582
XU2800 MAOI22D0BWP7T $PINS A2=n3816 ZN=n2095 A1=p<67> B2=p<67> VDD=VDD B1=n3816
+ VSS=VSS
XU2823 MAOI22D0BWP7T $PINS A2=p<74> ZN=n2114 A1=n3825 B2=p<74> VDD=VDD B1=n3825
+ VSS=VSS
Xicc_place1768 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3923 I=rin<122>
Xicc_place1766 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3921 I=rin<123>
Xicc_place1917 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n4072 I=n2830
XU3471 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3362 Z=n3120
XU3439 INVD0BWP7T $PINS ZN=n3088 VSS=VSS VDD=VDD I=n1056
XU3438 OA222D0BWP7T $PINS Z=n1056 B1=n2400 A1=n4054 A2=n2779 B2=n3861 C2=n3991
+ C1=n3922 VDD=VDD VSS=VSS
XU3437 INVD0BWP7T $PINS ZN=n3087 VSS=VSS VDD=VDD I=n1055
XU3436 OA222D0BWP7T $PINS Z=n1055 B1=n2401 A1=n4054 A2=n2400 B2=n3861 C2=n3991
+ C1=n3896 VDD=VDD VSS=VSS
XU3427 INVD0BWP7T $PINS ZN=n3078 VSS=VSS VDD=VDD I=n1140
XU3426 OA222D0BWP7T $PINS Z=n1140 B1=n3865 A1=n4055 A2=n2338 B2=n3857 C2=n3988
+ C1=n3904 VDD=VDD VSS=VSS
XU3425 INVD0BWP7T $PINS ZN=n3077 VSS=VSS VDD=VDD I=n1126
XU3424 OA222D0BWP7T $PINS Z=n1126 B1=n2350 A1=n4052 A2=n2349 B2=n3854 C2=n3993
+ C1=n3935 VDD=VDD VSS=VSS
XU3418 INVD0BWP7T $PINS ZN=n3071 VSS=VSS VDD=VDD I=n1075
XU3417 OA222D0BWP7T $PINS Z=n1075 B1=n2386 A1=n4054 A2=n3878 B2=n3859 C2=n3993
+ C1=n3932 VDD=VDD VSS=VSS
XU3415 INVD0BWP7T $PINS ZN=n3069 VSS=VSS VDD=VDD I=n1073
XU3414 OA222D0BWP7T $PINS Z=n1073 B1=n4462 A1=n4054 A2=n2387 B2=n3861 C2=n3991
+ C1=n2269 VDD=VDD VSS=VSS
XU3413 INVD0BWP7T $PINS ZN=n3068 VSS=VSS VDD=VDD I=n1072
XU3412 OA222D0BWP7T $PINS Z=n1072 B1=n3862 A1=n4054 A2=n4462 B2=n3861 C2=n3991
+ C1=n2271 VDD=VDD VSS=VSS
XU3408 INVD0BWP7T $PINS ZN=n3064 VSS=VSS VDD=VDD I=n1143
XU3407 OA222D0BWP7T $PINS Z=n1143 B1=n2336 A1=n4055 A2=n3866 B2=n3857 C2=n3988
+ C1=n3930 VDD=VDD VSS=VSS
XU3401 INVD0BWP7T $PINS ZN=n3058 VSS=VSS VDD=VDD I=n1138
XU3400 OA222D0BWP7T $PINS Z=n1138 B1=n2340 A1=n4052 A2=n2341 B2=n3854 C2=n3993
+ C1=n3962 VDD=VDD VSS=VSS
XU3394 INVD0BWP7T $PINS ZN=n3052 VSS=VSS VDD=VDD I=n1102
XU3393 OA222D0BWP7T $PINS Z=n1102 B1=n2369 A1=n4055 A2=n2370 B2=n3857 C2=n3997
+ C1=n3952 VDD=VDD VSS=VSS
XU3392 INVD0BWP7T $PINS ZN=n3051 VSS=VSS VDD=VDD I=n1053
XU3391 OA222D0BWP7T $PINS Z=n1053 B1=n4464 A1=n4054 A2=n2403 B2=n3861 C2=n3995
+ C1=n3957 VDD=VDD VSS=VSS
XU3389 INVD0BWP7T $PINS ZN=n3049 VSS=VSS VDD=VDD I=n1163
XU3388 OA222D0BWP7T $PINS Z=n1163 B1=n2317 A1=n4054 A2=n2318 B2=n3861 C2=n3995
+ C1=n2454 VDD=VDD VSS=VSS
XU3354 INVD2BWP7T $PINS VDD=VDD VSS=VSS I=rout<51> ZN=n3010
XU3343 INVD0BWP7T $PINS ZN=n2999 VSS=VSS VDD=VDD I=n1153
XU3342 OA222D0BWP7T $PINS Z=n1153 B1=n2326 A1=n4054 A2=n2325 B2=n3861 C2=n3991
+ C1=n2689 VDD=VDD VSS=VSS
XU3313 INVD0BWP7T $PINS ZN=n2963 VSS=VSS VDD=VDD I=n1133
XU3312 OA222D0BWP7T $PINS Z=n1133 B1=n2345 A1=n4054 A2=n2344 B2=n3861 C2=n3991
+ C1=n4112 VDD=VDD VSS=VSS
XU3286 INVD0BWP7T $PINS ZN=n2923 VSS=VSS VDD=VDD I=n1113
XU3285 OA222D0BWP7T $PINS Z=n1113 B1=n2362 A1=n4054 A2=n2360 B2=n3861 C2=n3995
+ C1=n4179 VDD=VDD VSS=VSS
XU3284 INVD0BWP7T $PINS ZN=n2922 VSS=VSS VDD=VDD I=n1063
XU3283 OA222D0BWP7T $PINS Z=n1063 B1=n2396 A1=n4054 A2=n2394 B2=n3859 C2=n3993
+ C1=n4174 VDD=VDD VSS=VSS
XU3251 INVD0BWP7T $PINS ZN=n2866 VSS=VSS VDD=VDD I=n1132
XU3250 OA222D0BWP7T $PINS Z=n1132 B1=n2346 A1=n4054 A2=n2345 B2=n3861 C2=n3991
+ C1=n4178 VDD=VDD VSS=VSS
XU3249 INVD0BWP7T $PINS ZN=n2865 VSS=VSS VDD=VDD I=n1081
XU3248 OA222D0BWP7T $PINS Z=n1081 B1=n3877 A1=n4054 A2=n2776 B2=n3859 C2=n3993
+ C1=n4147 VDD=VDD VSS=VSS
XU3247 INVD0BWP7T $PINS ZN=n2864 VSS=VSS VDD=VDD I=n1062
XU3246 OA222D0BWP7T $PINS Z=n1062 B1=n2395 A1=n4054 A2=n2396 B2=n3859 C2=n3993
+ C1=n4173 VDD=VDD VSS=VSS
XU2346 AOI21D0BWP7T $PINS VSS=VSS A2=n1621 VDD=VDD A1=n4020 B=n1620 ZN=n1622
XU1915 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3859 ZN=n1726 A2=n2315
XU2062 OAI22D1BWP7T $PINS B1=n3969 A2=n3978 ZN=n1381 A1=round<2> VDD=VDD
+ B2=n1726 VSS=VSS
XU2064 NR4D0BWP7T $PINS VSS=VSS A4=n1380 VDD=VDD ZN=n1806 A3=n1381 A2=n1418
+ A1=n1530
XU2094 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1832 A2=n4292
XU2038 MUX2ND0BWP7T $PINS ZN=n1369 I1=n2004 I0=n4384 S=n1367 VDD=VDD VSS=VSS
XU1765 INVD2BWP7T $PINS ZN=n2271 VSS=VSS VDD=VDD I=rout<83>
XU1753 CKND1BWP7T $PINS ZN=n2269 VSS=VSS VDD=VDD I=rout<90>
XU1862 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1278 A1=n3990 ZN=N175 A2=n1279
XU2829 MAOI22D0BWP7T $PINS A2=p<77> ZN=n2118 A1=n4334 B2=p<77> VDD=VDD B1=n4334
+ VSS=VSS
Xicc_place1665 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3819 ZN=n3820
Xicc_place1663 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3817 ZN=n3818
Xicc_place1760 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3915 I=rin<37>
Xicc_place1801 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3956 I=rin<45>
Xicc_place1661 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3815 ZN=n3816
Xicc_place1604 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3759 I=k<36>
Xicc_place1611 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3766 I=k<44>
Xicc_place1603 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=k<35> ZN=n3758
Xicc_place1606 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=k<37> ZN=n3761
Xicc_place1778 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3933 I=rin<114>
Xicc_place1671 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3826 I=k<107>
Xicc_place1668 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3823 I=k<104>
Xicc_place1809 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3964 I=rin<113>
Xicc_place1750 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3905 I=rin<53>
Xicc_place1660 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3815 I=k<99>
Xicc_place1662 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3817 I=k<100>
XU2091 NR4D4BWP7T $PINS VSS=VSS A4=n4296 VDD=VDD ZN=n1828 A3=n1398 A2=n1399
+ A1=n1400
XU2470 OAI211D1BWP7T $PINS VSS=VSS C=n1750 VDD=VDD A2=n3998 ZN=rk0<13> A1=n4331
+ B=n1751
XU2429 OAI211D2BWP7T $PINS VSS=VSS C=n1712 VDD=VDD A2=n3998 ZN=rk0<9> A1=n1714
+ B=n1713
XU2160 OAI211D1BWP7T $PINS VSS=VSS C=n1802 VDD=VDD A2=n3984 ZN=rk1<17> A1=n1459
+ B=n1458
XU2528 OAI211D1BWP7T $PINS VSS=VSS C=n1824 VDD=VDD A2=n3984 ZN=rk0<19> A1=n1826
+ B=n1825
XU2348 OAI211D1BWP7T $PINS VSS=VSS C=n1791 VDD=VDD A2=n3982 ZN=rk0<1> A1=n1623
+ B=n1622
XU1930 OAI211D1BWP7T $PINS VSS=VSS C=n1305 VDD=VDD A2=n1307 ZN=rk1<1> A1=n4021
+ B=n1306
XU1991 OAI22D0BWP7T $PINS ZN=n1339 A1=n1338 A2=n3648 B2=n4000 VDD=VDD B1=n1337
+ VSS=VSS
XU2112 OAI22D1BWP7T $PINS ZN=n1414 A1=n1413 A2=n4016 B2=n3998 VDD=VDD B1=n1412
+ VSS=VSS
XU2390 OAI211D1BWP7T $PINS VSS=VSS C=n1674 VDD=VDD A2=n1676 ZN=rk0<5> A1=n4021
+ B=n1675
XU2035 NR4D0BWP7T $PINS VSS=VSS VDD=VDD ZN=n1442 A1=n1400 A2=n1552 A4=n1362
+ A3=n1363
XU2000 AOI32D1BWP7T $PINS B2=n1373 B1=round<1> A1=n1723 A2=n3852 ZN=n1343
+ VDD=VDD A3=n3968 VSS=VSS
Xrin_reg_125_ DFCNQD2BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I4 CDN=n3846 D=N222
+ Q=rin<125>
XU3710 INVD0BWP7T $PINS ZN=n3461 VSS=VSS VDD=VDD I=n3462
XU3707 INVD0BWP7T $PINS ZN=n3458 VSS=VSS VDD=VDD I=n3569
XU3705 INVD0BWP7T $PINS ZN=n3456 VSS=VSS VDD=VDD I=n1139
XU3704 INVD0BWP7T $PINS ZN=n3455 VSS=VSS VDD=VDD I=n1158
XU3666 OA222D0BWP7T $PINS Z=n1158 B1=n2321 A1=n4055 A2=n2322 B2=n3857 C2=n3997
+ C1=n3906 VDD=VDD VSS=VSS
XU1773 INVD0BWP7T $PINS ZN=n3449 VSS=VSS VDD=VDD I=n4336
XU2833 AOI22D2BWP7T $PINS B1=n4051 A2=n4015 ZN=n2119 A1=n3799 VDD=VDD B2=n3947
+ VSS=VSS
XU3450 OAI211D1BWP7T $PINS VSS=VSS C=n1616 VDD=VDD A2=n3855 ZN=n3099 A1=n1761
+ B=n1617
XU1956 OAI22D1BWP7T $PINS ZN=n1318 A1=n3858 A2=n1409 B2=n1428 VDD=VDD B1=n1681
+ VSS=VSS
XU1564 INVD1BWP7T $PINS ZN=n2454 VSS=VSS VDD=VDD I=n2453
XU2289 OAI22D1BWP7T $PINS ZN=n1566 A1=n1565 A2=n4016 B2=n3998 VDD=VDD B1=n1564
+ VSS=VSS
XU2239 OAI22D1BWP7T $PINS ZN=n1523 A1=n1522 A2=n4016 B2=n3998 VDD=VDD B1=n1521
+ VSS=VSS
XU2253 OAI22D2BWP7T $PINS ZN=n1534 A1=n1533 A2=n4016 B2=n3998 VDD=VDD B1=n1532
+ VSS=VSS
XU2039 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1445 A2=n3296
XU2365 MAOI22D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1642 ZN=n1648 A1=n3983 B2=n4371
+ B1=n3973
XU2105 NR4D4BWP7T $PINS VSS=VSS VDD=VDD ZN=n1485 A1=n1411 A2=n1552 A4=n4027
+ A3=n1410
XU2031 OAI22D1BWP7T $PINS ZN=n1363 A1=n3853 A2=n1593 B2=n3858 VDD=VDD B1=n1373
+ VSS=VSS
XU1816 ND2D8BWP7T $PINS VSS=VSS VDD=VDD A1=round<1> ZN=n1762 A2=n3859
XU3695 OAI211D0BWP7T $PINS A2=n1755 ZN=n3363 A1=n1681 B=n1586 VDD=VDD C=n1585
+ VSS=VSS
XU3694 OAI211D0BWP7T $PINS A2=n1754 ZN=n3362 A1=n3859 B=n1531 VDD=VDD C=n1627
+ VSS=VSS
XU3693 OAI211D1BWP7T $PINS A2=n1762 ZN=n3361 A1=n1527 B=n1597 VDD=VDD C=n1520
+ VSS=VSS
XU3691 OAI211D2BWP7T $PINS A2=n1755 ZN=n3359 A1=n3852 B=n4011 VDD=VDD C=n1335
+ VSS=VSS
XU3690 OAI211D1BWP7T $PINS A2=n1755 ZN=n3358 A1=n3852 B=n4011 VDD=VDD C=n1335
+ VSS=VSS
XU3687 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2375 Z=n3355
XU3686 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2367 Z=n3354
XU3676 OAI211D0BWP7T $PINS A2=n2314 ZN=n3344 A1=n3852 B=n3858 VDD=VDD C=n2312
+ VSS=VSS
XU3656 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1897 Z=n3320
XU3654 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1897 Z=n3318
XU3512 INVD0BWP7T $PINS ZN=n3170 VSS=VSS VDD=VDD I=n1909
XU3015 OAI222D2BWP7T $PINS B1=n3354 A1=n4055 A2=n2366 B2=n3857 C2=n3997
+ ZN=n1105 VDD=VDD C1=n3890 VSS=VSS
XU3012 OAI222D2BWP7T $PINS B1=n2364 A1=n4055 A2=n2363 B2=n3857 C2=n3995
+ ZN=n1108 VDD=VDD C1=n3965 VSS=VSS
XU3013 OAI222D2BWP7T $PINS B1=n2365 A1=n4055 A2=n2364 B2=n3857 C2=n3997
+ ZN=n1107 VDD=VDD C1=n3927 VSS=VSS
XU2967 OAI222D2BWP7T $PINS B1=n3866 A1=n4052 A2=n2334 B2=n3857 C2=n3988
+ ZN=n1144 VDD=VDD C1=n3937 VSS=VSS
XU2999 OAI222D2BWP7T $PINS B1=n2355 A1=n4052 A2=n2356 B2=n3854 C2=n3993
+ ZN=n1120 VDD=VDD C1=n3960 VSS=VSS
XU2998 OAI222D2BWP7T $PINS B1=n2356 A1=n4054 A2=n3867 B2=n3854 C2=n3993
+ ZN=n1121 VDD=VDD C1=n3909 VSS=VSS
XU2997 OAI222D2BWP7T $PINS B1=n3867 A1=n4054 A2=n3883 B2=n3854 C2=n3993
+ ZN=n1122 VDD=VDD C1=n3902 VSS=VSS
XU2995 OAI222D2BWP7T $PINS B1=n2352 A1=n4054 A2=n3864 B2=n3854 C2=n3991
+ ZN=n1124 VDD=VDD C1=n3944 VSS=VSS
XU2985 OAI222D2BWP7T $PINS B1=n2347 A1=n4054 A2=n2348 B2=n3854 C2=n3993
+ ZN=n1130 VDD=VDD C1=n4141 VSS=VSS
XU3003 OAI222D2BWP7T $PINS B1=n2358 A1=n4054 A2=n2357 B2=n3854 C2=n3991
+ ZN=n1116 VDD=VDD C1=n4171 VSS=VSS
XU2984 OAI222D2BWP7T $PINS B1=n2348 A1=n4054 A2=n2346 B2=n3854 C2=n3991
+ ZN=n1131 VDD=VDD C1=n4170 VSS=VSS
XU3028 OAI222D2BWP7T $PINS B1=n2371 A1=n4055 A2=n2383 B2=n3857 C2=n3988
+ ZN=n1096 VDD=VDD C1=n2749 VSS=VSS
XU3008 OAI222D2BWP7T $PINS B1=n2361 A1=n4054 A2=n2362 B2=n3861 C2=n3995
+ ZN=n1112 VDD=VDD C1=n4181 VSS=VSS
XU3080 OAI222D2BWP7T $PINS B1=n2408 A1=n4054 A2=n2407 B2=n3861 C2=n3991
+ ZN=n1047 VDD=VDD C1=n4144 VSS=VSS
XU2959 OAI222D2BWP7T $PINS B1=n2331 A1=n4054 A2=n2329 B2=n3861 C2=n3991
+ ZN=n1149 VDD=VDD C1=n4169 VSS=VSS
XU2961 OAI222D2BWP7T $PINS B1=n2332 A1=n4054 A2=n2347 B2=n3854 C2=n3993
+ ZN=n1147 VDD=VDD C1=n4166 VSS=VSS
XU3063 OAI222D2BWP7T $PINS B1=n2394 A1=n4054 A2=n2393 B2=n3861 C2=n3993
+ ZN=n1064 VDD=VDD C1=n4167 VSS=VSS
XU3038 OAI222D2BWP7T $PINS B1=n2377 A1=n4052 A2=n2376 B2=n3859 C2=n3993
+ ZN=n1086 VDD=VDD C1=n4111 VSS=VSS
XU3081 OAI222D2BWP7T $PINS B1=n2409 A1=n4054 A2=n2408 B2=n3861 C2=n3991
+ ZN=n1046 VDD=VDD C1=n4182 VSS=VSS
XU3082 OAI222D2BWP7T $PINS B1=n3871 A1=n4054 A2=n2409 B2=n3861 C2=n3991
+ ZN=n1045 VDD=VDD C1=n4143 VSS=VSS
XU2958 OAI222D2BWP7T $PINS B1=n2329 A1=n4054 A2=n2328 B2=n3861 C2=n3991
+ ZN=n1150 VDD=VDD C1=n4183 VSS=VSS
XU3047 AO222D0BWP7T $PINS Z=n1078 C2=n3987 C1=n3251 B1=n3880 A2=l<94> A1=n3855
+ VDD=VDD B2=n4053 VSS=VSS
XU3079 OAI222D2BWP7T $PINS B1=n2407 A1=n4054 A2=n3876 B2=n3861 C2=n3991
+ ZN=n1048 VDD=VDD C1=n4120 VSS=VSS
XU3045 OAI222D2BWP7T $PINS B1=n2778 A1=n4055 A2=n3877 B2=n3857 C2=n3988
+ ZN=n1080 VDD=VDD C1=n4175 VSS=VSS
XU2939 OAI222D2BWP7T $PINS B1=n2316 A1=n4054 A2=n2330 B2=n3861 C2=n3991
+ ZN=n1165 VDD=VDD C1=n4146 VSS=VSS
XU3043 OAI222D2BWP7T $PINS B1=n2776 A1=n4054 A2=n2380 B2=n3861 C2=n3993
+ ZN=n1082 VDD=VDD C1=n2727 VSS=VSS
XU3078 OAI222D2BWP7T $PINS B1=n3876 A1=n4054 A2=n2405 B2=n3861 C2=n3995
+ ZN=n1049 VDD=VDD C1=n4109 VSS=VSS
XU3061 OAI222D2BWP7T $PINS B1=n2392 A1=n4054 A2=n2391 B2=n3859 C2=n3993
+ ZN=n1066 VDD=VDD C1=n2692 VSS=VSS
XU3083 OAI222D2BWP7T $PINS B1=n2412 A1=n4054 A2=n3871 B2=n3861 C2=n3995
+ ZN=n1044 VDD=VDD C1=n4176 VSS=VSS
XU3084 OAI222D2BWP7T $PINS B1=n2781 A1=n4054 A2=n2412 B2=n3861 C2=n3995
+ ZN=n1043 VDD=VDD C1=n4145 VSS=VSS
XU3042 OAI222D2BWP7T $PINS B1=n2380 A1=n4054 A2=n2379 B2=n3859 C2=n3993
+ ZN=n1083 VDD=VDD C1=n4110 VSS=VSS
XU2952 OAI222D2BWP7T $PINS B1=n2325 A1=n4054 A2=n2324 B2=n3861 C2=n3991
+ ZN=n1154 VDD=VDD C1=n4115 VSS=VSS
XU3046 OAI222D2BWP7T $PINS B1=n2383 A1=n4055 A2=n2778 B2=n3857 C2=n3988
+ ZN=n1079 VDD=VDD C1=n4148 VSS=VSS
XU2868 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2143 A1=n3806 VDD=VDD
+ B2=rout<90> VSS=VSS
XU2851 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2131 A1=n3805 VDD=VDD B2=n3905
+ VSS=VSS
XU2832 MAOI22D1BWP7T $PINS A2=p<79> ZN=n2120 A1=n3830 B2=p<79> VDD=VDD B1=n3830
+ VSS=VSS
XU1861 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n1278 A1=n4309 VDD=VDD B2=n3910
+ VSS=VSS
XU1859 MAOI22D1BWP7T $PINS A2=n3829 ZN=n1279 A1=p<78> B2=p<78> VDD=VDD B1=n3829
+ VSS=VSS
XU2830 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2117 A1=k<77> VDD=VDD B2=n3956
+ VSS=VSS
XU2827 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2115 A1=n4308 VDD=VDD
+ B2=rin<44> VSS=VSS
XU2826 MAOI22D0BWP7T $PINS A2=p<76> ZN=n2116 A1=n3828 B2=p<76> VDD=VDD B1=n3828
+ VSS=VSS
XU2824 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2113 A1=n4321 VDD=VDD
+ B2=rin<42> VSS=VSS
XU2821 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2110 A1=n4307 VDD=VDD
+ B2=rin<41> VSS=VSS
XU2820 MAOI22D0BWP7T $PINS A2=p<73> ZN=n2111 A1=n3824 B2=p<73> VDD=VDD B1=n3824
+ VSS=VSS
XU2818 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2108 A1=n4384 VDD=VDD
+ B2=rin<40> VSS=VSS
XU2817 MAOI22D2BWP7T $PINS A2=p<72> ZN=n2109 A1=n3823 B2=p<72> VDD=VDD B1=n3823
+ VSS=VSS
XU2815 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2106 A1=n4383 VDD=VDD B2=n3914
+ VSS=VSS
XU2812 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2103 A1=n3796 VDD=VDD
+ B2=rout<70> VSS=VSS
XU2805 AOI22D0BWP7T $PINS B1=n4049 A2=n4014 ZN=n2097 A1=n3792 VDD=VDD B2=n3916
+ VSS=VSS
XU2806 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4361 A1=n3990 ZN=N165 A2=n2098
XU2795 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2087 A1=n3790 VDD=VDD B2=n3868
+ VSS=VSS
XU2796 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n4276 A1=n3988 ZN=N162 A2=n2088
XU2792 AOI22D1BWP7T $PINS B1=n4049 A2=n4012 ZN=n2084 A1=n4329 VDD=VDD B2=n2479
+ VSS=VSS
XU2752 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2075 A1=n3997 ZN=N128 A2=n2076
XU2741 MAOI22D1BWP7T $PINS A2=n2066 ZN=n2068 A1=p<28> B2=p<28> VDD=VDD B1=n2066
+ VSS=VSS
XU2743 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2067 A1=n3997 ZN=N125 A2=n2068
XU2729 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2053 A1=n3988 ZN=N121 A2=n2054
XU2725 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2049 A1=n3740 VDD=VDD
+ B2=rin<119> VSS=VSS
XU2724 MAOI22D0BWP7T $PINS A2=n2048 ZN=n2050 A1=n3712 B2=n3712 VDD=VDD B1=n2048
+ VSS=VSS
XU2726 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2049 A1=n3993 ZN=N120 A2=n2050
XU2698 AOI22D1BWP7T $PINS B1=n4050 A2=n4012 ZN=n2028 A1=n3730 VDD=VDD
+ B2=rin<111> VSS=VSS
XU2699 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2028 A1=n3988 ZN=N112 A2=n2029
XU2696 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2025 A1=n3988 ZN=N111 A2=n2026
XU2693 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2022 A1=n3995 ZN=N110 A2=n2023
XU2687 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2018 A1=n4381 VDD=VDD B2=n3939
+ VSS=VSS
XU2686 MAOI22D1BWP7T $PINS A2=n2016 ZN=n2019 A1=n4302 B2=n4302 VDD=VDD B1=n2016
+ VSS=VSS
XU2688 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n2018 A1=n3993 ZN=N109 A2=n2019
XU2684 AOI22D1BWP7T $PINS B1=n4049 A2=n4014 ZN=n2014 A1=n4380 VDD=VDD B2=n3958
+ VSS=VSS
XU2683 MAOI22D1BWP7T $PINS A2=n3798 ZN=n2015 A1=p<11> B2=p<11> VDD=VDD B1=n3798
+ VSS=VSS
XU2685 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n4272 A1=n3988 ZN=N108 A2=n2015
XU2681 AOI22D2BWP7T $PINS B1=n4050 A2=n4012 ZN=n2011 A1=n3726 VDD=VDD B2=n3940
+ VSS=VSS
XU2682 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2011 A1=n3997 ZN=N107 A2=n2012
XU2678 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n4436 A1=n3995 ZN=N106 A2=n2009
XU2674 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n2005 A1=n4315 VDD=VDD B2=n3941
+ VSS=VSS
XU2675 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n2005 A1=n3993 ZN=N105 A2=n2006
XU2669 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1999 A1=n3997 ZN=N103 A2=n2000
XU2665 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1996 A1=n3995 ZN=N102 A2=n1997
XU2659 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1990 A1=n3995 ZN=N101 A2=n1991
XU2651 AOI22D2BWP7T $PINS B1=n4049 A2=n4014 ZN=n1983 A1=n3224 VDD=VDD B2=n3887
+ VSS=VSS
XU2652 OAI21D2BWP7T $PINS VSS=VSS VDD=VDD B=n1983 A1=n3995 ZN=N99 A2=n1984
XU2648 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1980 A1=n3724 ZN=N98 A2=n4323
Xl_reg_82_ DFCND2BWP7T $PINS D=n1148 Q=l<82> CDN=n3847 QN=n2330 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_121_ DFCND0BWP7T $PINS D=n4368 Q=l<121> CDN=n3850 QN=n2373 CP=clk_G1B4I1
+ VSS=VSS VDD=VDD
Xl_reg_20_ DFCND0BWP7T $PINS D=n1117 Q=l<20> CDN=n3847 QN=n2357 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_87_ DFCND0BWP7T $PINS D=n1061 Q=l<87> CDN=n3845 CP=clk_G1B4I2 VSS=VSS
+ VDD=VDD
Xl_reg_38_ DFCND0BWP7T $PINS D=n1052 Q=l<38> CDN=n3844 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_36_ DFCND0BWP7T $PINS D=n1088 Q=l<36> CDN=n3844 CP=clk_G1B4I1 VSS=VSS
+ VDD=VDD
Xl_reg_19_ DFCND0BWP7T $PINS D=n3573 Q=l<19> CDN=n3847 QN=n2343 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
Xl_reg_62_ DFCND0BWP7T $PINS D=n1123 Q=l<62> CDN=n3847 QN=n2353 CP=clk_G1B4I3
+ VSS=VSS VDD=VDD
XU1794 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3948 ZN=c<47> A2=n4002
XU1770 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3966 ZN=c<49> A2=n4002
XU1768 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3908 ZN=c<50> A2=n4002
XU1766 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n2271 ZN=c<51> A2=n4293
XU1764 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n2285 ZN=c<52> A2=n4002
XU1780 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3906 ZN=c<53> A2=n4293
XU1762 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3904 ZN=c<54> A2=n4002
XU1756 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3898 ZN=c<57> A2=n4002
XU1754 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n2269 ZN=c<58> A2=n4002
XU1752 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3896 ZN=c<59> A2=n4293
XU1750 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3894 ZN=c<60> A2=n4002
XU1739 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3892 ZN=c<61> A2=n4002
XU1746 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3946 ZN=c<62> A2=n4002
XU1737 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3950 ZN=c<96> A2=n4002
XU1813 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4002 ZN=c<98> A1=n3887
XU1808 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4002 ZN=c<99> A1=n3886
XU1815 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4002 ZN=c<100> A1=n3885
XU1812 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4002 ZN=c<101> A1=n3884
XU1807 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4002 ZN=c<102> A1=rout<6>
XU1748 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n2454 ZN=c<103> A2=n4002
XU1809 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<104> A1=n3941
XU1805 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<105> A1=n3953
XU1806 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<106> A1=n3940
XU1814 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<107> A1=n3958
XU1804 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<109> A1=n3963
XU1730 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<110> A1=n3938
XU1784 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3937 ZN=c<111> A2=n4006
XU1713 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3965 ZN=c<113> A2=n4006
XU1731 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4294 ZN=c<114> A1=n3933
XU1711 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3932 ZN=c<115> A2=n4294
XU1732 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4004 ZN=c<117> A1=rout<21>
XU1719 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3930 ZN=c<118> A2=n4006
XU1727 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3926 ZN=c<121> A2=n4004
XU1707 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3924 ZN=c<122> A2=n4294
XU1729 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3922 ZN=c<123> A2=n4006
XU1725 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3955 ZN=c<124> A2=n4006
XU1723 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3942 ZN=c<125> A2=n4004
XU1709 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3944 ZN=c<126> A2=n4294
XU1744 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3920 ZN=c<127> A2=n4004
XU2960 OAI222D2BWP7T $PINS B1=n2330 A1=n4054 A2=n2331 B2=n3861 C2=n3991
+ ZN=n1148 VDD=VDD C1=n4165 VSS=VSS
XU2996 OAI222D2BWP7T $PINS B1=n3883 A1=n4054 A2=n2352 B2=n3854 C2=n3991
+ ZN=n1123 VDD=VDD C1=n3946 VSS=VSS
XU3018 OAI222D2BWP7T $PINS B1=n2370 A1=n4055 A2=n2368 B2=n3857 C2=n3995
+ ZN=n1103 VDD=VDD C1=n3966 VSS=VSS
XU3034 OAI222D1BWP7T $PINS B1=n2374 A1=n4054 A2=n3355 B2=n3861 C2=n3995
+ ZN=n1090 VDD=VDD C1=n3908 VSS=VSS
XU2992 OAI222D2BWP7T $PINS B1=n3864 A1=n4052 A2=n2350 B2=n3854 C2=n3993
+ ZN=n1125 VDD=VDD C1=n3929 VSS=VSS
XU2940 OAI222D2BWP7T $PINS B1=n2318 A1=n4054 A2=n2316 B2=n3861 C2=n3995
+ ZN=n1164 VDD=VDD C1=n3950 VSS=VSS
XU2950 OAI222D2BWP7T $PINS B1=n2324 A1=n4054 A2=n2323 B2=n3861 C2=n3991
+ ZN=n1155 VDD=VDD C1=n2480 VSS=VSS
XU2944 OAI222D2BWP7T $PINS B1=n2320 A1=n4055 A2=n2319 B2=n3857 C2=n3997
+ ZN=n1160 VDD=VDD C1=n3955 VSS=VSS
XU3016 OAI222D2BWP7T $PINS B1=n2368 A1=n4055 A2=n3354 B2=n3857 C2=n3997
+ ZN=n1104 VDD=VDD C1=n3900 VSS=VSS
Xicc_place1664 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<101> Z=n3819
Xicc_place1762 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3917 I=rin<35>
Xicc_place1659 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3813 ZN=n3814
Xicc_place1683 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<120> Z=n3838
Xicc_place1591 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3746 I=k<27>
Xicc_place1670 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<106> Z=n3825
Xicc_place1643 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3797 ZN=n3798
Xicc_place1629 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3784 I=k<61>
Xicc_place1625 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3780 I=k<58>
Xicc_place1657 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3811 ZN=n3812
Xicc_place1658 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3813 I=k<98>
Xicc_place1726 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<36> Z=n3881
Xicc_place1686 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3841 I=k<125>
Xicc_place1761 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3916 I=rin<36>
Xicc_place1763 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3918 I=rin<34>
Xicc_place1776 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3931 I=rin<115>
Xicc_place1713 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3868 I=rin<33>
Xicc_place1673 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<108> Z=n3828
Xicc_place1779 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3934 I=rin<112>
Xicc_place1589 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3744 I=k<26>
Xicc_place1599 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<33> Z=n3754
Xicc_place1587 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<24> Z=n3742
Xicc_place1655 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3810 I=k<96>
Xicc_place1609 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3764 I=k<43>
Xicc_place1723 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2385 Z=n3878
Xicc_place1642 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<75> Z=n3797
Xicc_place1652 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3807 I=k<93>
Xicc_place1593 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3748 I=k<29>
Xicc_place1577 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3732 I=k<16>
Xicc_place1684 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3839 I=k<122>
Xicc_place1656 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3811 I=k<97>
Xicc_place1623 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3778 I=k<56>
XU2139 OAI211D1BWP7T $PINS A2=n1439 ZN=rk1<15> A1=n4021 B=n1438 VDD=VDD C=n1437
+ VSS=VSS
XU2626 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n1949 A2=n1950 A1=n3985 ZN=n1956
+ C=n1948
XU1818 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1759 ZN=n1409 A2=n2312
XU2228 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=round<3> ZN=n1559 A2=n3853
XU1597 CKND1BWP7T $PINS ZN=n2480 VSS=VSS VDD=VDD I=n2479
XU1792 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n2480 ZN=c<32> A2=n4002
XU1799 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<34> A1=n3918
XU1796 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<35> A1=n3917
XU1797 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<36> A1=n3916
XU1802 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<37> A1=n3915
XU1795 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<38> A1=rout<70>
XU1798 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<39> A1=n3914
XU1790 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3962 ZN=c<40> A2=n4293
XU1788 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3960 ZN=c<41> A2=n4293
XU1778 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3952 ZN=c<42> A2=n4002
XU1800 INR2XD4BWP7T $PINS VSS=VSS VDD=VDD B1=n4293 ZN=c<43> A1=n3913
XU1776 NR2D5BWP7T $PINS VSS=VSS VDD=VDD A1=n3912 ZN=c<44> A2=n4293
XU1774 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3957 ZN=c<45> A2=n4293
Xicc_place1627 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3782 I=k<59>
Xicc_place1646 BUFFD12BWP7T $PINS VSS=VSS VDD=VDD Z=n3801 I=k<80>
Xicc_place1873 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n1862 ZN=n4028
Xicc_place1685 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3840 I=k<123>
Xicc_place1639 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<69> Z=n3794
Xicc_place1887 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n3361 Z=n4042
Xicc_place1680 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3835 I=k<116>
Xicc_place1678 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3833 I=k<114>
XU1999 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n1584 ZN=n1373 A2=n3967
XU1870 ND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3853 ZN=n1407 A2=n2314
XU1916 NR2XD2BWP7T $PINS VSS=VSS VDD=VDD A1=n1723 ZN=n1641 A2=n1726
XU1970 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3967 ZN=n1755 A2=n2314
XU2130 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3978 ZN=n1653 A2=n3968
XU2117 AOI22D2BWP7T $PINS B1=n3974 A2=n3853 ZN=n1510 A1=n1418 VDD=VDD B2=n3858
+ VSS=VSS
XU2116 AOI22D1BWP7T $PINS B1=n1625 A2=n1584 ZN=n1624 A1=n3859 VDD=VDD B2=n3967
+ VSS=VSS
XU2594 AOI22D2BWP7T $PINS B1=n2401 A2=l<59> ZN=n1918 A1=n3169 VDD=VDD B2=n2584
+ VSS=VSS
XU2328 AOI22D1BWP7T $PINS B1=l<32> A2=n2324 ZN=n1609 A1=n3617 VDD=VDD B2=n4045
+ VSS=VSS
XU2215 OAI22D2BWP7T $PINS B1=n1762 A2=n1754 ZN=n1665 A1=n3978 VDD=VDD B2=n3968
+ VSS=VSS
XU2382 NR3D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1666 A1=round<1> A3=n1664 A2=n3853
XU2383 AOI211XD2BWP7T $PINS VSS=VSS VDD=VDD B=n1666 A2=n3977 A1=n3975 ZN=n1670
+ C=n1665
XU2493 AOI22D1BWP7T $PINS B1=n2350 A2=l<112> ZN=n1793 A1=n4074 VDD=VDD B2=n1783
+ VSS=VSS
XU2494 AOI22D2BWP7T $PINS B1=l<48> A2=n2356 ZN=n1790 A1=n4074 VDD=VDD B2=n1783
+ VSS=VSS
XU2520 AOI22D1BWP7T $PINS B1=n2386 A2=l<115> ZN=n1826 A1=n4026 VDD=VDD B2=n3626
+ VSS=VSS
XU2521 AOI22D1BWP7T $PINS B1=l<51> A2=n3862 ZN=n1823 A1=n4026 VDD=VDD B2=n3626
+ VSS=VSS
XU2421 AOI22D2BWP7T $PINS B1=n2355 A2=l<41> ZN=n1714 A1=n4040 VDD=VDD B2=n4042
+ VSS=VSS
XU2422 AOI22D2BWP7T $PINS B1=l<105> A2=n2349 ZN=n1711 A1=n4040 VDD=VDD B2=n4039
+ VSS=VSS
XU2603 AOI22D1BWP7T $PINS B1=n2322 A2=l<60> ZN=n1933 A1=n4098 VDD=VDD B2=n4270
+ VSS=VSS
XU2604 AOI22D1BWP7T $PINS B1=l<124> A2=n2320 ZN=n1929 A1=n4098 VDD=VDD B2=n4270
+ VSS=VSS
XU2585 AOI22D2BWP7T $PINS B1=n4462 A2=l<58> ZN=n1907 A1=n2582 VDD=VDD B2=n3320
+ VSS=VSS
XU2586 AOI22D2BWP7T $PINS B1=l<122> A2=n2387 ZN=n1902 A1=n2582 VDD=VDD B2=n3320
+ VSS=VSS
XU2373 AO211D1BWP7T $PINS Z=n1657 C=n1652 B=n1653 A2=n3979 VDD=VDD A1=n1654
+ VSS=VSS
XU2567 AOI22D2BWP7T $PINS B1=l<120> A2=n2365 ZN=n1880 A1=n4040 VDD=VDD B2=n4042
+ VSS=VSS
XU2621 OAI211D2BWP7T $PINS A2=n3982 ZN=rk0<29> A1=n1944 B=n1943 VDD=VDD C=n1942
+ VSS=VSS
XU2539 AOI22D1BWP7T $PINS B1=n2321 A2=l<53> ZN=n1849 A1=n4046 VDD=VDD B2=n3623
+ VSS=VSS
XU2540 AOI22D1BWP7T $PINS B1=l<117> A2=n2319 ZN=n1844 A1=n4046 VDD=VDD B2=n3623
+ VSS=VSS
XU3621 OAI211D1BWP7T $PINS A2=n3855 ZN=n3285 A1=n1761 B=n1617 VDD=VDD C=n1616
+ VSS=VSS
XU2576 AOI22D1BWP7T $PINS B1=n2375 A2=l<57> ZN=n1896 A1=n4064 VDD=VDD B2=n4071
+ VSS=VSS
XU2432 AOI22D2BWP7T $PINS B1=l<106> A2=n2363 ZN=n1719 A1=n4064 VDD=VDD B2=n4063
+ VSS=VSS
XU2293 AOI22D2BWP7T $PINS B1=n2371 A2=l<93> ZN=n1580 A1=n2610 VDD=VDD B2=n1570
+ VSS=VSS
XU2294 AOI22D2BWP7T $PINS B1=l<29> A2=n2376 ZN=n1577 A1=n2610 VDD=VDD B2=n3159
+ VSS=VSS
XU2256 AOI22D2BWP7T $PINS B1=n2342 A2=l<26> ZN=n1548 A1=n4043 VDD=VDD B2=n4044
+ VSS=VSS
XU2257 AOI22D2BWP7T $PINS B1=l<90> A2=n2332 ZN=n1543 A1=n4043 VDD=VDD B2=n4044
+ VSS=VSS
XU1944 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1542 A2=n4043
XU2193 MAOI22D1BWP7T $PINS A2=n4041 ZN=n1490 A1=l<85> B2=l<85> VDD=VDD B1=n4041
+ VSS=VSS
XU1980 OAI211D0BWP7T $PINS A2=n1334 ZN=rk1<4> A1=n4021 B=n1333 VDD=VDD C=n1332
+ VSS=VSS
XU2286 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1925 A2=n4098
XU2250 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1890 A2=n4064
XU2236 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1878 A2=n4040
XU2140 AOI22D1BWP7T $PINS B1=n2391 A2=l<16> ZN=n1451 A1=n3296 VDD=VDD B2=n2622
+ VSS=VSS
XU2142 AOI22D2BWP7T $PINS B1=n3875 A2=n2395 ZN=n1446 A1=n3296 VDD=VDD B2=n2622
+ VSS=VSS
XU1961 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1912 A2=n1909
XU1884 AOI21D0BWP7T $PINS VSS=VSS A2=n1584 VDD=VDD A1=n1625 B=n1530 ZN=n1651
XU2001 NR4D3BWP7T $PINS VSS=VSS A4=n4295 VDD=VDD ZN=n1946 A3=n1344 A2=n1345
+ A1=n1388
XU2070 OAI22D2BWP7T $PINS B1=n1382 A2=n4016 ZN=n1384 A1=n1383 VDD=VDD B2=n4000
+ VSS=VSS
XU2129 AOI21D2BWP7T $PINS VSS=VSS A2=n1428 VDD=VDD A1=n3976 B=n3859 ZN=n1431
XU2132 NR4D4BWP7T $PINS VSS=VSS A4=n1430 VDD=VDD ZN=n1433 A3=n1653 A2=n1431
+ A1=n1641
XU2327 AOI22D1BWP7T $PINS B1=n2318 A2=l<96> ZN=n1611 A1=n3617 VDD=VDD B2=n4045
+ VSS=VSS
XU2352 ND4D2BWP7T $PINS VSS=VSS VDD=VDD A2=n1679 ZN=n1629 A1=n1725 A3=n1627
+ A4=n1626
XU2548 AOI22D1BWP7T $PINS B1=n3865 A2=l<54> ZN=n1860 A1=n4073 VDD=VDD B2=n4072
+ VSS=VSS
XU2549 AOI22D2BWP7T $PINS B1=l<118> A2=n2336 ZN=n1857 A1=n4073 VDD=VDD B2=n4072
+ VSS=VSS
XU2484 AOI22D2BWP7T $PINS B1=l<47> A2=n2341 ZN=n1779 A1=n4062 VDD=VDD B2=n4065
+ VSS=VSS
XU2483 AOI22D1BWP7T $PINS B1=n3866 A2=l<111> ZN=n1782 A1=n4062 VDD=VDD B2=n4061
+ VSS=VSS
XU2412 AOI22D1BWP7T $PINS B1=n2340 A2=l<40> ZN=n1706 A1=n1862 VDD=VDD B2=n4028
+ VSS=VSS
XU2413 AOI22D1BWP7T $PINS B1=l<104> A2=n2334 ZN=n1703 A1=n1862 VDD=VDD B2=n4028
+ VSS=VSS
XU2478 OAI22D1BWP7T $PINS B1=n1765 A2=n4016 ZN=n1767 A1=n1766 VDD=VDD B2=n3998
+ VSS=VSS
XU2622 AOI22D2BWP7T $PINS B1=n3883 A2=l<62> ZN=n1958 A1=n4373 VDD=VDD B2=n4010
+ VSS=VSS
XU2623 AOI22D2BWP7T $PINS B1=l<126> A2=n2352 ZN=n1950 A1=n4373 VDD=VDD B2=n4010
+ VSS=VSS
XU2631 AOI22D2BWP7T $PINS B1=n2366 A2=l<127> ZN=n1973 A1=n3617 VDD=VDD B2=n4045
+ VSS=VSS
XU2632 AOI22D1BWP7T $PINS B1=l<63> A2=n2367 ZN=n1968 A1=n3617 VDD=VDD B2=n4045
+ VSS=VSS
XU2557 AOI22D2BWP7T $PINS B1=n3867 A2=l<55> ZN=n1871 A1=n1862 VDD=VDD B2=n4028
+ VSS=VSS
XU2402 AOI22D1BWP7T $PINS B1=n2323 A2=l<39> ZN=n1698 A1=n4073 VDD=VDD B2=n4072
+ VSS=VSS
XU2403 AOI22D1BWP7T $PINS B1=l<103> A2=n2317 ZN=n1695 A1=n4073 VDD=VDD B2=n4072
+ VSS=VSS
XU2318 AOI22D2BWP7T $PINS B1=n2397 A2=l<95> ZN=n1603 A1=n3617 VDD=VDD B2=n4045
+ VSS=VSS
XU2321 AOI22D2BWP7T $PINS B1=n4045 A2=n3617 ZN=n1598 A1=l<31> VDD=VDD B2=n2404
+ VSS=VSS
XU2325 CKND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3970 ZN=n1970 A2=n4045
XU2151 AOI22D1BWP7T $PINS B1=n2412 A2=l<81> ZN=n1459 A1=n4038 VDD=VDD B2=n3360
+ VSS=VSS
XU2152 AOI22D1BWP7T $PINS B1=l<17> A2=n3876 ZN=n1457 A1=n4038 VDD=VDD B2=n3360
+ VSS=VSS
XU2208 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1855 A2=n4073
XU2162 AOI22D1BWP7T $PINS B1=n2326 A2=l<18> ZN=n1467 A1=n4008 VDD=VDD B2=n4009
+ VSS=VSS
XU2067 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1810 A2=n4008
XU2163 AOI22D1BWP7T $PINS B1=l<82> A2=n2330 ZN=n1464 A1=n4008 VDD=VDD B2=n4009
+ VSS=VSS
XU2221 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1866 A2=n1862
XU1890 ND3D1BWP7T $PINS VSS=VSS VDD=VDD A2=n1284 A1=n4374 ZN=n1289 A3=n1560
XU2006 NR2D1P5BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1949 A2=n4373
XU1817 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3853 ZN=n1759 A2=n2314
Xicc_place1818 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3972 ZN=n3973
Xicc_place1718 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<64> Z=n3873
Xicc_place1828 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=n3983 I=n3982
Xicc_place1647 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3802 I=k<81>
Xicc_place1651 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<90> Z=n3806
Xicc_place1716 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n2410 Z=n3871
Xicc_place1893 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4047 ZN=n4048
Xicc_place1568 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=k<0> ZN=n3723
Xicc_place1581 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<21> Z=n3736
Xicc_place2158 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<64> Z=n4329
Xicc_place1649 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3804 I=k<84>
XU3098 INVD1BWP7T $PINS ZN=n2749 VSS=VSS VDD=VDD I=n2873
XU3353 INVD0BWP7T $PINS ZN=n3009 VSS=VSS VDD=VDD I=n3010
XU3211 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3529 ZN=c<82>
XU3055 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<3> I=n3510
XU2231 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1757 A2=n1664 A1=n1625 ZN=n1520
+ C=n1640
XU2073 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3853 ZN=n1583 A2=n3978
XU2104 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n1636 A1=n3858 ZN=n1497 A2=n1409
XU2089 AOI22D2BWP7T $PINS B1=n1508 A2=n1407 ZN=n1398 A1=n3859 VDD=VDD B2=n3855
+ VSS=VSS
XU1871 ND3D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1428 A1=n1612 ZN=n1290 A3=n1407
XU1881 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=round<2> ZN=n1723 A2=n2314
XU1867 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3859 ZN=n1528 A2=n3852
XU2047 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=round<3> ZN=n1754 A2=n3967
XU2452 AOI22D1BWP7T $PINS B1=n2389 A2=l<44> ZN=n1744 A1=n1735 VDD=VDD B2=n3624
+ VSS=VSS
XU2453 AOI22D2BWP7T $PINS B1=l<108> A2=n3878 ZN=n1739 A1=n1735 VDD=VDD B2=n3624
+ VSS=VSS
XU2462 AOI22D2BWP7T $PINS B1=n4464 A2=l<45> ZN=n1752 A1=n4098 VDD=VDD B2=n4270
+ VSS=VSS
XU2955 OAI22D2BWP7T $PINS B1=n3980 A2=n1755 ZN=n3178 A1=n3852 VDD=VDD B2=n1407
+ VSS=VSS
XU2614 AOI22D2BWP7T $PINS B1=l<61> A2=n2338 ZN=n1941 A1=n4047 VDD=VDD B2=n4048
+ VSS=VSS
XU2613 AOI22D2BWP7T $PINS B1=n2337 A2=l<125> ZN=n1944 A1=n4047 VDD=VDD B2=n4048
+ VSS=VSS
XU1920 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n3853 ZN=n1761 A2=n3969
XU2529 AOI22D1BWP7T $PINS B1=n2403 A2=l<52> ZN=n1837 A1=n4292 VDD=VDD B2=n4024
+ VSS=VSS
XU2530 AOI22D1BWP7T $PINS B1=l<116> A2=n2399 ZN=n1834 A1=n4292 VDD=VDD B2=n4024
+ VSS=VSS
XU2511 AOI22D1BWP7T $PINS B1=n2374 A2=n3863 ZN=n1815 A1=n4008 VDD=VDD B2=n4009
+ VSS=VSS
XU2512 AOI22D1BWP7T $PINS B1=l<114> A2=n2372 ZN=n1812 A1=n4008 VDD=VDD B2=n4009
+ VSS=VSS
XU2503 AOI22D1BWP7T $PINS B1=l<49> A2=n2370 ZN=n1801 A1=n4038 VDD=VDD B2=n4037
+ VSS=VSS
XU2502 AOI22D1BWP7T $PINS B1=n2364 A2=l<113> ZN=n1804 A1=n4038 VDD=VDD B2=n4037
+ VSS=VSS
XU2273 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3971 ZN=n1738 A2=n1735
XU1938 OAI31D1BWP7T $PINS VSS=VSS VDD=VDD B=n1309 ZN=n1310 A3=n1681 A2=n2315
+ A1=n2314
XU1939 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1530 A2=n3858 A1=n3967 ZN=n1539
+ C=n1310
XU2230 AOI21D2BWP7T $PINS VSS=VSS A2=n3852 VDD=VDD A1=n3981 B=n1582 ZN=n1597
XU2314 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1593 A1=round<2> ZN=n1594 A2=n1681
XU2315 AOI22D2BWP7T $PINS B1=n2315 A2=n3858 ZN=n1680 A1=n3974 VDD=VDD B2=n1594
+ VSS=VSS
XU2303 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n1582 A2=n1583 A1=n1584 ZN=n1585
+ C=n3992
XU2302 AOI22D2BWP7T $PINS B1=n3979 A2=n1581 ZN=n1586 A1=n1625 VDD=VDD B2=n1654
+ VSS=VSS
XU2051 AOI211XD1BWP7T $PINS VSS=VSS VDD=VDD B=n1370 A2=n3981 A1=round<1>
+ ZN=n1371 C=n1640
XU2046 AOI31D2BWP7T $PINS B=n1641 ZN=n1372 A1=round<2> A2=n3852 VDD=VDD
+ A3=n1407 VSS=VSS
XU2216 OAI22D2BWP7T $PINS B1=n3980 A2=n1761 ZN=n1512 A1=n3852 VDD=VDD B2=n1508
+ VSS=VSS
XU2968 OAI22D2BWP7T $PINS B1=n1762 A2=n1754 ZN=n3338 A1=n3978 VDD=VDD B2=n3968
+ VSS=VSS
XU2183 AOI22D1BWP7T $PINS B1=l<84> A2=n2361 ZN=n1481 A1=n1828 VDD=VDD B2=n4024
+ VSS=VSS
XU1971 OAI22D1BWP7T $PINS B1=n3980 A2=n1755 ZN=n1639 A1=n3852 VDD=VDD B2=n1407
+ VSS=VSS
XU1972 AOI211D2BWP7T $PINS VSS=VSS VDD=VDD B=n3974 A2=n1664 A1=n1625 ZN=n1328
+ C=n1639
XU1914 AOI22D1BWP7T $PINS B1=n3979 A2=n1759 ZN=n1336 A1=round<1> VDD=VDD
+ B2=n2312 VSS=VSS
XU1913 ND2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1723 ZN=n1664 A2=n1508
XU1880 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=round<3> ZN=n1584 A2=round<2>
XU1883 NR2D2BWP7T $PINS VSS=VSS VDD=VDD A1=n1723 ZN=n1530 A2=n1496
XU1839 INVD0BWP7T $PINS ZN=n3570 VSS=VSS VDD=VDD I=n1060
XU1836 OA222D0BWP7T $PINS Z=n1060 B1=n2397 A1=n4055 A2=n2781 B2=n3857 C2=n3997
+ C1=n4172 VDD=VDD VSS=VSS
XU1772 OAI211D2BWP7T $PINS A2=n1754 ZN=n3585 A1=n3859 B=n1531 VDD=VDD C=n1627
+ VSS=VSS
XU1758 OA222D0BWP7T $PINS Z=n3569 B1=n2338 A1=n4055 A2=n2337 B2=n3857 C2=n3990
+ C1=n3892 VDD=VDD VSS=VSS
XU1741 OA222D0BWP7T $PINS Z=n3568 B1=n2366 A1=n4055 A2=n2365 B2=n3857 C2=n3997
+ C1=n3920 VDD=VDD VSS=VSS
XU1740 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3567 A2=n4002 A1=n3909
XU1721 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3566 A2=n4006 A1=n3929
XU1717 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3565 A2=n4002 A1=n2281
XU1715 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3564 A2=n4006 A1=n3927
XU1704 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3563 A2=n4002 A1=n3900
XU1700 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3562 A2=n4002 A1=n3890
XU1697 OA222D0BWP7T $PINS Z=n3561 B1=n2344 A1=n4054 A2=n3882 B2=n3854 C2=n3991
+ C1=n4121 VDD=VDD VSS=VSS
XU1694 AO221D1BWP7T $PINS Z=n3560 C=n4294 B1=n2418 A2=rout<104> A1=k<40>
+ VDD=VDD B2=n4147 VSS=VSS
XU1691 AO221D1BWP7T $PINS Z=n3559 C=n4002 B1=n1209 A2=rout<50> A1=k<18> VDD=VDD
+ B2=n2689 VSS=VSS
XU1688 AO221D1BWP7T $PINS Z=n3558 C=n4004 B1=n3785 A2=n2873 A1=n3784 VDD=VDD
+ B2=n2749 VSS=VSS
XU1685 AO221D1BWP7T $PINS Z=n3557 C=n4004 B1=n3775 A2=rout<118> A1=n3774
+ VDD=VDD B2=n4148 VSS=VSS
XU1682 AO221D2BWP7T $PINS Z=n3556 C=n4006 B1=n1234 A2=n4260 A1=n4315 VDD=VDD
+ B2=n2691 VSS=VSS
XU1679 AO221D1BWP7T $PINS Z=n3554 C=n4006 B1=n1202 A2=rout<102> A1=k<38>
+ VDD=VDD B2=n4177 VSS=VSS
XU1673 AO221D2BWP7T $PINS Z=n3553 C=n4004 B1=n3743 A2=rout<56> A1=n3742 VDD=VDD
+ B2=n4131 VSS=VSS
XU1670 AO221D1BWP7T $PINS Z=n3552 C=n4006 B1=n1176 A2=rout<52> A1=k<20> VDD=VDD
+ B2=n4129 VSS=VSS
XU1664 AO221D0BWP7T $PINS Z=n3551 C=n4002 B1=n3765 A2=n4168 A1=n3764 VDD=VDD
+ B2=n4169 VSS=VSS
XU1662 AO221D1BWP7T $PINS Z=n3550 C=n4294 B1=n1233 A2=rout<44> A1=n4381 VDD=VDD
+ B2=n4121 VSS=VSS
XU1660 AO221D2BWP7T $PINS Z=n3548 C=n4004 B1=n3739 A2=rout<54> A1=n3738 VDD=VDD
+ B2=n4111 VSS=VSS
XU1658 AO221D1BWP7T $PINS Z=n3547 C=n4006 B1=n3735 A2=n3009 A1=n3734 VDD=VDD
+ B2=n3010 VSS=VSS
XU1655 AO221D2BWP7T $PINS Z=n3546 C=n4004 B1=n1240 A2=n4341 A1=k<53> VDD=VDD
+ B2=n4193 VSS=VSS
XU1652 AO221D1BWP7T $PINS Z=n3545 C=n4006 B1=n3755 A2=n2983 A1=n3754 VDD=VDD
+ B2=n2727 VSS=VSS
XU1649 AO221D1BWP7T $PINS Z=n3544 C=n4006 B1=n3773 A2=n4140 A1=n3772 VDD=VDD
+ B2=n4141 VSS=VSS
XU1645 AO211D0BWP7T $PINS Z=n3542 C=n1314 B=n1542 A2=n1315 VDD=VDD A1=n3985
+ VSS=VSS
XU1643 AO221D1BWP7T $PINS Z=n3541 C=n4004 B1=n2417 A2=n4354 A1=k<39> VDD=VDD
+ B2=n4151 VSS=VSS
XU1640 AO221D2BWP7T $PINS Z=n3540 C=n4002 B1=n1329 A2=rout<36> A1=n4451 VDD=VDD
+ B2=n4118 VSS=VSS
XU1637 AO221D1BWP7T $PINS Z=n3539 C=n4006 B1=n1244 A2=rout<43> A1=n4380 VDD=VDD
+ B2=n4128 VSS=VSS
XU1631 AO221D2BWP7T $PINS Z=n3538 C=n4006 B1=n1253 A2=rout<45> A1=n4457 VDD=VDD
+ B2=n4171 VSS=VSS
XU1628 AO221D2BWP7T $PINS Z=n3537 C=n4294 B1=n3724 A2=rout<33> A1=k<1> VDD=VDD
+ B2=n4110 VSS=VSS
XU1625 AO221D1BWP7T $PINS Z=n3536 C=n4006 B1=n3741 A2=n3003 A1=n3740 VDD=VDD
+ B2=n2696 VSS=VSS
XU1604 AO221D1BWP7T $PINS Z=n3532 C=n4006 B1=n3781 A2=rout<122> A1=n3780
+ VDD=VDD B2=n4166 VSS=VSS
XU1595 AO221D0BWP7T $PINS Z=n3530 C=n4004 B1=n3787 A2=n3251 A1=n3786 VDD=VDD
+ B2=n2739 VSS=VSS
XU1592 AO221D0BWP7T $PINS Z=n3529 C=n4002 B1=n1238 A2=n4164 A1=n4399 VDD=VDD
+ B2=n4165 VSS=VSS
XU1589 AO221D1BWP7T $PINS Z=n3528 C=n4004 B1=n3769 A2=rout<111> A1=n3768
+ VDD=VDD B2=n4175 VSS=VSS
XU1586 AO221D1BWP7T $PINS Z=n3527 C=n4004 B1=n3783 A2=n4161 A1=n3782 VDD=VDD
+ B2=n4162 VSS=VSS
XU1583 AO221D1BWP7T $PINS Z=n3526 C=n4004 B1=n1214 A2=n4256 A1=n4459 VDD=VDD
+ B2=n4146 VSS=VSS
XU1580 AO221D1BWP7T $PINS Z=n3525 C=n4006 B1=n1232 A2=rout<116> A1=n4400
+ VDD=VDD B2=n4181 VSS=VSS
XU1577 AO221D1BWP7T $PINS Z=n3524 C=n4006 B1=n3767 A2=rout<108> A1=n3766
+ VDD=VDD B2=n4170 VSS=VSS
XU1574 AO221D1BWP7T $PINS Z=n3523 C=n4006 B1=n3761 A2=rout<101> A1=k<37>
+ VDD=VDD B2=n4178 VSS=VSS
XU1571 AO221D1BWP7T $PINS Z=n3522 C=n4004 B1=n3729 A2=rout<46> A1=n3728 VDD=VDD
+ B2=n4130 VSS=VSS
XU1568 AO221D1BWP7T $PINS Z=n3521 C=n4004 B1=n3789 A2=rout<127> A1=n3788
+ VDD=VDD B2=n4172 VSS=VSS
XU1562 AO221D1BWP7T $PINS Z=n3520 C=n4006 B1=n2416 A2=n4351 A1=k<32> VDD=VDD
+ B2=n2710 VSS=VSS
XU1553 AO221D1BWP7T $PINS Z=n3518 C=n4294 B1=n1243 A2=rout<37> A1=n4390 VDD=VDD
+ B2=n4112 VSS=VSS
XU1547 AO221D1BWP7T $PINS Z=n3516 C=n4294 B1=n3733 A2=rout<48> A1=n3732 VDD=VDD
+ B2=n4133 VSS=VSS
XU1544 AO221D1BWP7T $PINS Z=n3515 C=n4004 B1=n3749 A2=rout<61> A1=n3748 VDD=VDD
+ B2=n4180 VSS=VSS
XU1541 AO221D1BWP7T $PINS Z=n3514 C=n4294 B1=n3763 A2=rout<105> A1=n3762
+ VDD=VDD B2=n4174 VSS=VSS
XU1538 AO221D1BWP7T $PINS Z=n3513 C=n4004 B1=n3779 A2=rout<120> A1=n3778
+ VDD=VDD B2=n4145 VSS=VSS
XU1534 AO221D2BWP7T $PINS Z=n3512 C=n4002 B1=n1219 A2=rout<38> A1=n4391 VDD=VDD
+ B2=n4114 VSS=VSS
XU1525 AO221D1BWP7T $PINS Z=n3511 C=n4004 B1=n2421 A2=rout<109> A1=n4398
+ VDD=VDD B2=n4179 VSS=VSS
XU1522 AO221D0BWP7T $PINS Z=n3510 C=n4002 B1=n1247 A2=rout<35> A1=n4456 VDD=VDD
+ B2=n4144 VSS=VSS
XU1519 AO221D2BWP7T $PINS Z=n3509 C=n4006 B1=n3771 A2=rout<112> A1=n3770
+ VDD=VDD B2=n4173 VSS=VSS
XU1516 AO221D2BWP7T $PINS Z=n3508 C=n4006 B1=n3723 A2=rout<32> A1=k<0> VDD=VDD
+ B2=n4122 VSS=VSS
XU1513 AO221D2BWP7T $PINS Z=n3507 C=n4004 B1=n3725 A2=rout<39> A1=k<7> VDD=VDD
+ B2=n4123 VSS=VSS
XU1510 AO211D0BWP7T $PINS Z=n3506 C=n1756 B=n1757 A2=n3977 VDD=VDD A1=n1759
+ VSS=VSS
Xrin_reg_103_ DFCNQD2BWP7T $PINS D=N200 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<103>
Xrin_reg_126_ DFCNQD1BWP7T $PINS D=N223 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<126>
Xrin_reg_62_ DFCNQD1BWP7T $PINS D=N159 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<62>
Xrin_reg_47_ DFCNQD1BWP7T $PINS D=N144 CDN=n3851 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<47>
Xrin_reg_96_ DFCNQD1BWP7T $PINS D=N193 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<96>
Xrin_reg_42_ DFCNQD1BWP7T $PINS D=N139 CDN=n3850 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<42>
Xrin_reg_105_ DFCNQD1BWP7T $PINS D=N202 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<105>
Xrin_reg_124_ DFCNQD1BWP7T $PINS D=N221 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<124>
XU2290 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1925 A2=n1567 A1=n3983 ZN=n1568
+ C=n1566
XU2460 OAI211D2BWP7T $PINS A2=n3998 ZN=rk0<12> A1=n4266 B=n1743 VDD=VDD C=n1742
+ VSS=VSS
Xrin_reg_45_ DFCNQD1BWP7T $PINS D=N142 CDN=n3850 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=rin<45>
Xrin_reg_107_ DFCNQD1BWP7T $PINS D=N204 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<107>
Xrin_reg_41_ DFCNQD1BWP7T $PINS D=N138 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<41>
Xrin_reg_40_ DFCNQD1BWP7T $PINS D=N137 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=rin<40>
Xrin_reg_109_ DFCNQD1BWP7T $PINS D=N206 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<109>
Xrin_reg_113_ DFCNQD1BWP7T $PINS D=N210 CDN=n3846 CP=clk_G1B4I4 VSS=VSS VDD=VDD
+ Q=rin<113>
Xrin_reg_49_ DFCNQD1BWP7T $PINS D=N146 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=rin<49>
XU1942 MUX2ND1BWP7T $PINS ZN=n1317 I1=n1982 I0=n4453 S=n1315 VDD=VDD VSS=VSS
XU2344 CKXOR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n1618 A2=n3754 Z=n1619
XU2016 NR2D1BWP7T $PINS VSS=VSS VDD=VDD A1=n2312 ZN=n1418 A2=n1681
XU2050 NR2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3968 ZN=n1640 A2=n3980
XU1887 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n2314 A1=n3977 ZN=n1283 A2=n2307
XU1888 OAI21D1BWP7T $PINS B=n1283 A2=n3980 ZN=n1613 VDD=VDD A1=round<2> VSS=VSS
XU2102 AOI21D2BWP7T $PINS VSS=VSS A2=n1407 VDD=VDD A1=n1723 B=n1429 ZN=n1410
XU1954 OAI22D1BWP7T $PINS ZN=n1319 A1=n3859 A2=n1761 B2=n1762 VDD=VDD B1=n1407
+ VSS=VSS
XU1921 NR2XD1BWP7T $PINS VSS=VSS VDD=VDD A1=n3980 ZN=n1582 A2=n1761
XU1950 OAI22D0BWP7T $PINS B1=n1312 A2=n4016 ZN=n1314 A1=n1313 VDD=VDD B2=n4000
+ VSS=VSS
XU2455 AOI21D0BWP7T $PINS VSS=VSS A2=n1739 VDD=VDD A1=n3828 B=n1736 ZN=n1737
XU2456 AOI211XD0BWP7T $PINS VSS=VSS VDD=VDD B=n1738 A2=n1739 A1=n3983 ZN=n1743
+ C=n1737
XU2044 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1368 A1=n4021 ZN=rk1<8> A2=n1369
XU2625 AOI21D1BWP7T $PINS VSS=VSS A2=n1950 VDD=VDD A1=n3842 B=n1947 ZN=n1948
Xicc_place1721 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2406 Z=n3876
Xicc_place1720 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<80> Z=n3875
Xl_reg_85_ DFCND2BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3851 Q=l<85>
+ D=n1166
XU3632 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3296 I=n1442
XU2391 AOI21D0BWP7T $PINS VSS=VSS A2=n1726 VDD=VDD A1=n3978 B=n3976 ZN=n1683
XU2063 OAI22D1BWP7T $PINS B1=n1762 A2=n1754 ZN=n1380 A1=n3852 VDD=VDD B2=n1761
+ VSS=VSS
XU2281 AOI21D0BWP7T $PINS VSS=VSS A2=n1754 VDD=VDD A1=n2489 B=n3852 ZN=n1563
XU2282 OAI211D1BWP7T $PINS VSS=VSS C=n1560 VDD=VDD A2=n1681 ZN=n1562 A1=n2315
+ B=n3461
XU1497 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=n2315 ZN=n1400 A2=n1560
XU2243 AOI22D0BWP7T $PINS B1=n1761 A2=n1527 ZN=n1529 A1=n1528 VDD=VDD B2=n3980
+ VSS=VSS
Xround_reg_1_ EDFCND2BWP7T $PINS VSS=VSS VDD=VDD D=n1039 E=n3707 CP=clk_G1B4I3
+ Q=n2313 CDN=n3848 QN=round<1>
Xround_reg_4_ EDFCND2BWP7T $PINS VSS=VSS VDD=VDD D=n1042 E=n3707 CP=clk_G1B4I2
+ Q=n2315 CDN=n3848 QN=round<4>
Xround_reg_3_ EDFCND2BWP7T $PINS VSS=VSS VDD=VDD D=n1041 E=n3707 CP=clk_G1B4I2
+ Q=n2314 CDN=n3848 QN=round<3>
Xround_reg_0_ EDFCND1BWP7T $PINS VSS=VSS VDD=VDD D=n3859 E=n3707 CP=clk_G1B4I3
+ Q=n3658 CDN=n3848 QN=n2333
Xround_reg_2_ EDFCND2BWP7T $PINS VSS=VSS VDD=VDD D=n1040 E=n3707 CP=clk_G1B4I2
+ Q=n2312 CDN=n3848 QN=round<2>
Xl_reg_101_ DFCND1BWP7T $PINS D=n1077 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<101>
Xl_reg_44_ DFCND1BWP7T $PINS D=n3581 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<44> QN=n2389
Xl_reg_16_ DFCND1BWP7T $PINS D=n1067 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<16> QN=n2391
Xl_reg_114_ DFCND2BWP7T $PINS D=n1093 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=l<114> QN=n2372
Xl_reg_69_ DFCND1BWP7T $PINS D=n2866 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=l<69> QN=n2346
Xl_reg_68_ DFCND1BWP7T $PINS D=n1150 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ QN=n2329
Xl_reg_24_ DFCND2BWP7T $PINS D=n4345 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=l<24> QN=n2405
Xl_reg_43_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I1 CDN=n3844 Q=l<43>
+ D=n1089
Xl_reg_100_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3845 Q=l<100>
+ D=n1095
Xl_reg_98_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3845 Q=l<98>
+ D=n1128
Xl_reg_84_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I3 QN=n2361 CDN=n3844
+ Q=l<84> D=n1112
Xl_reg_109_ DFCND2BWP7T $PINS D=n1058 CDN=n3844 CP=clk_G1B4I1 VSS=VSS VDD=VDD
+ Q=l<109> QN=n2398
Xl_reg_104_ DFCND2BWP7T $PINS D=n1145 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<104> QN=n2334
XU1667 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4304 ZN=n2758 A2=rout<98>
+ B2=n4167 B1=n3756 C=n4294
XU1507 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n4397 ZN=n2760 A2=rout<49>
+ B2=n4109 B1=n2414 C=n4006
XU1601 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=k<42> ZN=n2755 A2=n4142 B2=n4143
+ B1=n2419 C=n4006
XU1634 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3224 ZN=n2764 A2=rout<34>
+ B2=n2702 B1=n1224 C=n4294
XU1530 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3730 ZN=n2761 A2=n3042 B2=n2679
+ B1=n3731 C=n4294
XU1622 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=k<35> ZN=n2757 A2=rout<99>
+ B2=n4182 B1=n3758 C=n4006
XU1565 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3726 ZN=n2762 A2=n4119 B2=n4120
+ B1=n3727 C=n4002
XU1613 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3471 ZN=n2754 A2=rout<113>
+ B2=n4176 B1=n2422 C=n4006
XU1556 AOI221D1BWP7T $PINS VSS=VSS VDD=VDD A1=n3244 ZN=n2763 A2=n3029 B2=n2692
+ B1=n1195 C=n4294
Xl_reg_94_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3845 Q=l<94>
+ D=n1078
Xl_reg_30_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3845 Q=l<30>
+ D=n1069
Xl_reg_86_ DFCND2BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I4 QN=n2383 CDN=n3851
+ D=n1079
Xl_reg_95_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I1 QN=n2397 CDN=n3844
+ Q=l<95> D=n3570
XU2118 OAI211D1BWP7T $PINS VSS=VSS C=n1510 VDD=VDD A2=n1428 ZN=n1419 A1=n3858
+ B=n1624
Xl_reg_47_ DFCND2BWP7T $PINS D=n3456 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<47> QN=n2341
Xl_reg_23_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3845 Q=l<23>
+ D=n1068
XU3168 OAI211D1BWP7T $PINS ZN=n2830 A2=n3852 A1=n1754 C=n1499 VDD=VDD B=n1500
+ VSS=VSS
Xl_reg_91_ DFCND1BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I1 CDN=n3844 Q=l<91>
+ D=n1129
XU2577 AOI22D2BWP7T $PINS ZN=n1893 A1=n4064 A2=n2373 B2=n4071 VDD=VDD B1=l<121>
+ VSS=VSS
XU1966 AOI211XD0BWP7T $PINS A1=n3985 ZN=n1325 A2=n1324 B=n1912 VDD=VDD C=n1323
+ VSS=VSS
Xl_reg_107_ DFCND2BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I2 CDN=n3851 Q=l<107>
+ D=n1094
XU2362 NR4D4BWP7T $PINS VSS=VSS VDD=VDD ZN=n1643 A1=n1641 A2=n1640 A4=n1638
+ A3=n3178
XU3622 OAI211D1BWP7T $PINS VSS=VSS C=n1616 VDD=VDD A2=n3855 ZN=n3286 A1=n1761
+ B=n1617
XU1984 OAI211D2BWP7T $PINS ZN=n1570 A2=n1755 A1=n3852 C=n1335 VDD=VDD B=n4011
+ VSS=VSS
Xl_reg_48_ DFCND2BWP7T $PINS VDD=VDD VSS=VSS CP=clk_G1B4I3 QN=n2356 CDN=n3848
+ Q=l<48> D=n1121
XU2218 NR3D3BWP7T $PINS A3=n1511 VSS=VSS VDD=VDD A1=n3338 A2=n1512 ZN=n1862
XU2171 AOI22D1BWP7T $PINS ZN=n1475 A1=n4026 A2=l<83> B2=n3626 VDD=VDD B1=n2347
+ VSS=VSS
XU2441 OAI211D2BWP7T $PINS ZN=n1897 A2=n1726 A1=round<3> C=n1724 VDD=VDD
+ B=n1725 VSS=VSS
XU2339 OAI211D2BWP7T $PINS VSS=VSS C=n1616 VDD=VDD A2=n3855 ZN=n1783 A1=n1761
+ B=n1617
XU2392 OAI211D0BWP7T $PINS VSS=VSS C=n1679 VDD=VDD A2=n2314 ZN=n1682 A1=n1681
+ B=n1680
XU3748 AOI21D1BWP7T $PINS A2=round<2> A1=round<3> ZN=n3498 VDD=VDD B=n3853
+ VSS=VSS
XU3108 AOI21D1BWP7T $PINS VSS=VSS A1=round<3> VDD=VDD B=n3853 ZN=n2770
+ A2=round<2>
XU3692 OAI211D2BWP7T $PINS ZN=n3360 A2=n1373 A1=n3859 C=n4445 VDD=VDD B=n1372
+ VSS=VSS
XU2337 AOI211XD2BWP7T $PINS A1=n3977 ZN=n1617 A2=n1654 B=n1614 VDD=VDD C=n4322
+ VSS=VSS
XU2090 AOI32D1BWP7T $PINS B2=n3852 B1=n1409 A1=round<3> A2=round<1> ZN=n1397
+ VDD=VDD A3=n1612 VSS=VSS
XU2972 INVD0BWP7T $PINS ZN=n3584 VSS=VSS VDD=VDD I=n1057
XU2970 OA222D0BWP7T $PINS Z=n1057 B1=n2779 A1=n4054 A2=n2398 B2=n3861 C2=n3991
+ C1=n2281 VDD=VDD VSS=VSS
XU2953 INVD0BWP7T $PINS ZN=n3582 VSS=VSS VDD=VDD I=n3583
XU2945 OA222D0BWP7T $PINS Z=n1139 B1=n2341 A1=n4052 A2=n3865 B2=n3857 C2=n3988
+ C1=n3948 VDD=VDD VSS=VSS
XU2925 INVD0BWP7T $PINS ZN=n3581 VSS=VSS VDD=VDD I=n1071
XU2863 OA222D0BWP7T $PINS Z=n1071 B1=n2389 A1=n4052 A2=n3862 B2=n3859 C2=n3993
+ C1=n3912 VDD=VDD VSS=VSS
XU2801 INVD0BWP7T $PINS ZN=n3580 VSS=VSS VDD=VDD I=n3568
XU2660 INVD0BWP7T $PINS ZN=n3577 VSS=VSS VDD=VDD I=n1159
XU2538 OA222D0BWP7T $PINS Z=n1159 B1=n2322 A1=n4055 A2=n2320 B2=n3857 C2=n3997
+ C1=n3894 VDD=VDD VSS=VSS
XU2531 INVD0BWP7T $PINS ZN=n3576 VSS=VSS VDD=VDD I=n1085
XU2504 OA222D0BWP7T $PINS Z=n1085 B1=n2378 A1=n4052 A2=n2377 B2=n3859 C2=n3993
+ C1=n2679 VDD=VDD VSS=VSS
XU2472 INVD0BWP7T $PINS ZN=n3575 VSS=VSS VDD=VDD I=n3561
XU2464 INVD0BWP7T $PINS ZN=n3574 VSS=VSS VDD=VDD I=n1115
XU1951 OA222D0BWP7T $PINS Z=n1115 B1=n2359 A1=n4054 A2=n2358 B2=n3861 C2=n3991
+ C1=n4114 VDD=VDD VSS=VSS
XU1943 INVD0BWP7T $PINS ZN=n3573 VSS=VSS VDD=VDD I=n1135
XU1907 OA222D0BWP7T $PINS Z=n1135 B1=n3882 A1=n4052 A2=n2342 B2=n3854 C2=n3993
+ C1=n3010 VDD=VDD VSS=VSS
XU1906 INVD0BWP7T $PINS ZN=n3572 VSS=VSS VDD=VDD I=n1084
XU1876 OA222D0BWP7T $PINS Z=n1084 B1=n2379 A1=n4052 A2=n2378 B2=n3859 C2=n3993
+ C1=n2691 VDD=VDD VSS=VSS
XU1853 INVD0BWP7T $PINS ZN=n3571 VSS=VSS VDD=VDD I=n1151
XU1846 OA222D0BWP7T $PINS Z=n1151 B1=n2328 A1=n4054 A2=n2327 B2=n3861 C2=n3991
+ C1=n4118 VDD=VDD VSS=VSS
Xicc_place1892 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4047 I=n3625
Xicc_place1714 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<21> Z=n3869
Xicc_place1650 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3805 I=k<85>
Xicc_place1571 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3726 I=k<10>
Xicc_place1885 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4039 ZN=n4040
Xicc_place1719 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<0> Z=n3874
Xicc_place1648 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3803 I=k<83>
Xicc_place1844 CKND6BWP7T $PINS VSS=VSS VDD=VDD ZN=n3999 I=n3998
Xicc_place1830 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=n3985 I=n3984
Xicc_place1637 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3792 I=k<68>
Xicc_place1579 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3734 I=k<19>
Xicc_place1827 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n3982 I=n3638
Xicc_place1677 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<113> Z=n3832
Xicc_place1681 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3836 I=k<117>
Xicc_place1676 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3831 I=k<112>
Xicc_place1829 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3984 I=n3638
Xicc_place1816 INVD5BWP7T $PINS VSS=VSS VDD=VDD ZN=n3971 I=n3970
Xicc_place1679 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3834 I=k<115>
Xicc_place1843 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3998 I=n3653
Xicc_place1870 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1328 Z=n4025
Xicc_place1884 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4039 I=n1872
Xl_reg_93_ DFCND2BWP7T $PINS D=n1096 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<93> QN=n2371
Xl_reg_11_ DFCND1BWP7T $PINS D=n4330 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=l<11> QN=n2327
XU3331 BUFFD1P5BWP7T $PINS VSS=VSS I=rout<97> VDD=VDD Z=n2983
XU3256 DEL01BWP7T $PINS VSS=VSS I=rout<125> VDD=VDD Z=n2873
XU3587 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3251 I=rout<126>
XU3721 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3471 I=k<49>
XU3560 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3224 I=k<2>
XU3580 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3244 I=k<9>
XU3368 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3029 I=rout<41>
XU3381 BUFFD1P5BWP7T $PINS VSS=VSS I=rout<47> VDD=VDD Z=n3042
XU1827 CKND2D1BWP7T $PINS ZN=n3630 A1=n2307 VDD=VDD A2=n1581 VSS=VSS
XU3116 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2384 Z=n2778
XU2021 OAI211D2BWP7T $PINS VSS=VSS C=n1353 VDD=VDD A2=n1409 ZN=n1355 A1=n3978
+ B=n3461
XU2099 OAI21D1BWP7T $PINS VSS=VSS VDD=VDD B=n1405 A1=n4021 ZN=rk1<12> A2=n1406
Xl_reg_105_ DFCND1BWP7T $PINS D=n1127 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<105> QN=n2349
XU3119 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=n2411 Z=n2781
Xl_reg_27_ DFCND1BWP7T $PINS D=n1118 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<27>
Xl_reg_89_ DFCND2BWP7T $PINS D=n1165 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ QN=n2316
Xl_reg_41_ DFCND2BWP7T $PINS D=n4283 CDN=n3848 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<41> QN=n2355
Xl_reg_32_ DFCND2BWP7T $PINS D=n1155 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=l<32> QN=n2324
Xl_reg_28_ DFCND1BWP7T $PINS D=n1100 CDN=n3851 CP=clk_G1B4I2 VSS=VSS VDD=VDD
+ Q=l<28>
XU3114 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2381 Z=n2776
XU3501 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3159 I=n3358
XU3468 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n3117 I=n2832
XU2269 ND4D0BWP7T $PINS VSS=VSS VDD=VDD A2=n1550 ZN=n1551 A1=n1637 A3=n1595
+ A4=n1549
Xl_reg_52_ DFCND2BWP7T $PINS D=n3582 CDN=n3847 CP=clk_G1B4I3 VSS=VSS VDD=VDD
+ Q=l<52> QN=n2403
XU1923 OAI211D2BWP7T $PINS VSS=VSS C=n1299 VDD=VDD A2=n1664 ZN=n1302 A1=n1681
+ B=n4011
XU2266 OAI211D0BWP7T $PINS VSS=VSS C=n2312 VDD=VDD A2=n2314 ZN=n1637 A1=n3852
+ B=n3858
Xicc_place1889 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4043 ZN=n4044
Xicc_place1635 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3790 I=k<65>
Xicc_place1617 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3772 I=k<51>
Xicc_place1727 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2343 Z=n3882
Xicc_place1615 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<48> Z=n3770
Xicc_place1909 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4063 ZN=n4064
Xicc_place1943 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4270 ZN=n4098
Xicc_place1854 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4008 ZN=n4009
Xicc_place2107 INVD6BWP7T $PINS VSS=VSS VDD=VDD ZN=n4270 I=n4271
Xicc_place1708 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<50> Z=n3863
Xicc_place1861 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4016 I=n3648
Xicc_place1891 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3623 ZN=n4046
Xicc_place1883 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4037 ZN=n4038
Xicc_place1908 CKBD3BWP7T $PINS VSS=VSS VDD=VDD I=n1884 Z=n4063
Xicc_place1724 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<20> Z=n3879
Xicc_place1882 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4037 I=n1794
Xicc_place1888 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4043 I=n4442
Xicc_place1853 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4008 I=n4290
Xicc_place1856 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1336 Z=n4011
Xicc_place1872 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1497 Z=n4027
Xicc_place1815 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n3970 I=n3498
Xicc_place1824 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3979 I=n1762
Xicc_place1700 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=n3855 I=n3854
Xicc_place1823 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1625 ZN=n3978
XU2633 INVD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1735 I=n3624
XU2595 NR2D3BWP7T $PINS VSS=VSS A2=n2312 VDD=VDD A1=n3853 ZN=n1654
XU2558 AOI22D0BWP7T $PINS B1=n1629 A2=n3983 ZN=n1634 A1=n1628 VDD=VDD B2=n3972
+ VSS=VSS
XU2550 OAI22D1BWP7T $PINS B1=n1502 A2=n3998 ZN=n1503 A1=n1501 VDD=VDD B2=n4016
+ VSS=VSS
XU2497 AO211D0BWP7T $PINS Z=n3629 C=n1562 B=n1563 A2=n3852 VDD=VDD A1=n1584
+ VSS=VSS
XU2473 OR2D2BWP7T $PINS VSS=VSS A1=n3619 VDD=VDD A2=n1762 Z=n3648
XU2393 INVD0BWP7T $PINS ZN=n3619 VSS=VSS VDD=VDD I=n1290
XU2355 IAO21D2BWP7T $PINS VSS=VSS VDD=VDD ZN=n3625 B=n3506 A2=n1761 A1=n1762
XU2316 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3653 A2=n3972 A1=n3978
XU2270 OR2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3638 A2=n1681 A1=n3970
XU2113 IAO21D1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3622 B=n3542 A2=n1317 A1=n4021
XU2017 AO211D0BWP7T $PINS Z=n3615 C=n1414 B=n1489 A2=n1415 VDD=VDD A1=n3983
+ VSS=VSS
XU2013 INVD0BWP7T $PINS ZN=n1416 VSS=VSS VDD=VDD I=n3615
XU1957 OR2D2BWP7T $PINS VSS=VSS VDD=VDD Z=n3665 A2=n3858 A1=n3992
XU1919 OAI221D2BWP7T $PINS B1=k<28> A1=n3613 ZN=n2871 B2=rout<60> VDD=VDD
+ C=done VSS=VSS A2=n4117
XU1904 INVD0BWP7T $PINS ZN=n3613 VSS=VSS VDD=VDD I=n4377
XU1896 AO221D1BWP7T $PINS Z=n2844 C=n4006 B1=n3759 A2=rout<100> A1=k<36>
+ VDD=VDD B2=n4183 VSS=VSS
XU1894 AN4D4BWP7T $PINS Z=n3617 A4=n1595 A3=n1596 A2=n1680 VDD=VDD A1=n1597
+ VSS=VSS
XU1893 AN2D1BWP7T $PINS VSS=VSS VDD=VDD Z=n3643 A2=n1290 A1=n1528
XU1872 ND2D3BWP7T $PINS VSS=VSS VDD=VDD A1=n3858 ZN=n1681 A2=n3852
XU1851 NR2D4BWP7T $PINS VSS=VSS VDD=VDD A1=round<1> ZN=n1625 A2=n3858
XU1841 AO211D0BWP7T $PINS Z=n3462 C=n1418 B=n2308 A2=n1654 VDD=VDD A1=round<1>
+ VSS=VSS
XU1820 AOI22D2BWP7T $PINS B1=n2584 A2=n3169 ZN=n1913 A1=n2400 VDD=VDD B2=l<123>
+ VSS=VSS
XU1810 OAI21D0BWP7T $PINS VSS=VSS VDD=VDD B=n4020 A1=n3840 ZN=n1910 A2=n1913
XU1801 AOI22D2BWP7T $PINS B1=n4028 A2=n1862 ZN=n1868 A1=n3864 VDD=VDD B2=l<119>
+ VSS=VSS
XU1787 AOI21D0BWP7T $PINS VSS=VSS A2=n3837 VDD=VDD A1=n1868 B=n4021 ZN=n1867
XU1743 IND2D1BWP7T $PINS A1=n3902 B1=done ZN=n3135 VDD=VDD VSS=VSS
XU1661 OA222D0BWP7T $PINS Z=n3583 B1=n2403 A1=n4054 A2=n2401 B2=n3861 C2=n3991
+ C1=n2285 VDD=VDD VSS=VSS
XU1648 IND2D1BWP7T $PINS A1=n4006 B1=n3939 ZN=n3131 VDD=VDD VSS=VSS
XU1646 OAI221D2BWP7T $PINS B1=n3776 A1=n3777 ZN=n3535 B2=n4429 VDD=VDD C=done
+ VSS=VSS A2=n4149
XU1619 OAI221D1BWP7T $PINS B1=n4458 A1=n3609 ZN=n3549 B2=rout<110> VDD=VDD
+ C=done VSS=VSS A2=n4150
XU1616 INVD0BWP7T $PINS ZN=n3609 VSS=VSS VDD=VDD I=n4458
XU1607 OAI221D1BWP7T $PINS B1=n4401 A1=n3607 ZN=n3555 B2=rout<124> VDD=VDD
+ C=done VSS=VSS A2=n4163
XU1606 INVD0BWP7T $PINS ZN=n3607 VSS=VSS VDD=VDD I=n4401
XU1578 OAI221D1BWP7T $PINS B1=n3744 A1=n3745 ZN=n3531 B2=n3033 VDD=VDD C=done
+ VSS=VSS A2=n3604
XU1549 INVD0BWP7T $PINS ZN=n3604 VSS=VSS VDD=VDD I=n3033
XU1548 OAI221D2BWP7T $PINS B1=n3750 A1=n3751 ZN=n3533 B2=rout<62> VDD=VDD
+ C=done VSS=VSS A2=n4132
XU1536 OAI221D1BWP7T $PINS B1=n3752 A1=n3753 ZN=n3517 B2=n4262 VDD=VDD C=done
+ VSS=VSS A2=n4263
XU1529 OAI221D1BWP7T $PINS B1=n3736 A1=n3737 ZN=n3534 B2=rout<53> VDD=VDD
+ C=done VSS=VSS A2=n4113
XU1518 CKND2D3BWP7T $PINS VSS=VSS A2=n3859 VDD=VDD A1=n1400 ZN=n3671
XU1514 OAI221D1BWP7T $PINS B1=n3746 A1=n3747 ZN=n3543 B2=rout<59> VDD=VDD
+ C=done VSS=VSS A2=n3596
XU1506 INVD0BWP7T $PINS ZN=n3596 VSS=VSS VDD=VDD I=rout<59>
XU3347 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=rout<55> Z=n3003
XU3372 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3033 I=rout<58>
XU2922 AO211D0BWP7T $PINS Z=n3628 C=n1529 B=n1530 A2=n1723 VDD=VDD A1=n1583
+ VSS=VSS
XU2917 INVD0BWP7T $PINS ZN=n1531 VSS=VSS VDD=VDD I=n3628
XU2916 AO211D0BWP7T $PINS VSS=VSS A1=n1528 VDD=VDD A2=n1664 B=n1319 C=n1318
+ Z=n3627
XU2888 AO211D2BWP7T $PINS VSS=VSS A1=n2312 VDD=VDD A2=n1039 B=n1389 C=n1582
+ Z=n3626
XU2702 INVD1BWP7T $PINS VSS=VSS VDD=VDD I=n3170 ZN=n3169
XU2691 AO211D1BWP7T $PINS VSS=VSS A1=n1559 VDD=VDD A2=n3980 B=n1552 C=n1551
+ Z=n3624
XU2662 AO211D2BWP7T $PINS Z=n3623 C=n1682 B=n1683 A2=n3859 VDD=VDD A1=n3981
+ VSS=VSS
XU2640 INVD1BWP7T $PINS VSS=VSS VDD=VDD ZN=n1909 I=n3627
Xport_protection_diode_0 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<74>
Xport_protection_diode_1 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<73>
Xport_protection_diode_2 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<72>
Xport_protection_diode_3 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<71>
Xport_protection_diode_4 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<70>
Xport_protection_diode_5 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<69>
Xport_protection_diode_6 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<68>
Xport_protection_diode_7 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<67>
Xport_protection_diode_8 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<66>
Xport_protection_diode_9 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<65>
Xport_protection_diode_10 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<64>
Xport_protection_diode_11 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<63>
Xport_protection_diode_12 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<62>
Xport_protection_diode_13 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<61>
Xport_protection_diode_14 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<60>
Xport_protection_diode_15 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<59>
Xport_protection_diode_16 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<58>
Xport_protection_diode_17 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<57>
Xport_protection_diode_18 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<56>
Xport_protection_diode_19 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<55>
Xport_protection_diode_20 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<54>
Xport_protection_diode_21 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<53>
Xport_protection_diode_22 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<52>
Xport_protection_diode_23 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<51>
Xport_protection_diode_24 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<50>
Xport_protection_diode_25 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<49>
Xport_protection_diode_26 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<48>
Xport_protection_diode_27 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<47>
Xport_protection_diode_28 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<46>
Xport_protection_diode_29 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<45>
Xport_protection_diode_30 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<44>
Xport_protection_diode_31 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<43>
Xport_protection_diode_32 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<42>
Xport_protection_diode_33 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<41>
Xport_protection_diode_34 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<40>
Xport_protection_diode_35 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<39>
Xport_protection_diode_36 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<38>
Xport_protection_diode_37 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<37>
Xport_protection_diode_38 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<36>
Xport_protection_diode_39 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<35>
Xport_protection_diode_40 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<34>
Xport_protection_diode_41 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<33>
Xport_protection_diode_42 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<32>
Xport_protection_diode_43 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<31>
Xport_protection_diode_44 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<30>
Xport_protection_diode_45 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<29>
Xport_protection_diode_46 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<28>
Xport_protection_diode_47 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<27>
Xport_protection_diode_48 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<26>
Xport_protection_diode_49 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<25>
Xport_protection_diode_50 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<24>
Xport_protection_diode_51 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<23>
Xport_protection_diode_52 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<22>
Xport_protection_diode_53 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<21>
Xport_protection_diode_54 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<20>
Xport_protection_diode_55 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<19>
Xport_protection_diode_56 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<18>
Xport_protection_diode_57 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<17>
Xport_protection_diode_58 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<16>
Xport_protection_diode_59 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<15>
Xport_protection_diode_60 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<14>
Xport_protection_diode_61 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<13>
Xport_protection_diode_62 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<12>
Xport_protection_diode_63 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<11>
Xport_protection_diode_64 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<10>
Xport_protection_diode_65 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<9>
Xport_protection_diode_66 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<8>
Xport_protection_diode_67 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<7>
Xport_protection_diode_68 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<6>
Xport_protection_diode_69 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<5>
Xport_protection_diode_70 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<4>
Xport_protection_diode_71 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<3>
Xport_protection_diode_72 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<2>
Xport_protection_diode_73 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<1>
Xport_protection_diode_74 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<0>
Xport_protection_diode_75 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=start
Xport_protection_diode_76 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<24>
Xport_protection_diode_77 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<23>
Xport_protection_diode_78 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<22>
Xport_protection_diode_79 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<21>
Xport_protection_diode_80 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<20>
Xport_protection_diode_81 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<19>
Xport_protection_diode_82 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<18>
Xport_protection_diode_83 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<17>
Xport_protection_diode_84 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<16>
Xport_protection_diode_85 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<15>
Xport_protection_diode_86 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<14>
Xport_protection_diode_87 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<13>
Xport_protection_diode_88 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<12>
Xport_protection_diode_89 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<11>
Xport_protection_diode_90 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<10>
Xport_protection_diode_91 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<9>
Xport_protection_diode_92 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<8>
Xport_protection_diode_93 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<7>
Xport_protection_diode_94 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<6>
Xport_protection_diode_95 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<5>
Xport_protection_diode_96 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<4>
Xport_protection_diode_97 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<3>
Xport_protection_diode_98 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<2>
Xport_protection_diode_99 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<1>
Xport_protection_diode_100 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<0>
Xport_protection_diode_101 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<127>
Xport_protection_diode_102 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<126>
Xport_protection_diode_103 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<125>
Xport_protection_diode_104 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<124>
Xport_protection_diode_105 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<123>
Xport_protection_diode_106 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<122>
Xport_protection_diode_107 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<121>
Xport_protection_diode_108 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<120>
Xport_protection_diode_109 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<119>
Xport_protection_diode_110 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<118>
Xport_protection_diode_111 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<117>
Xport_protection_diode_112 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<116>
Xport_protection_diode_113 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<115>
Xport_protection_diode_114 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<114>
Xport_protection_diode_115 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<113>
Xport_protection_diode_116 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<112>
Xport_protection_diode_117 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<111>
Xport_protection_diode_118 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<110>
Xport_protection_diode_119 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<109>
Xport_protection_diode_120 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<108>
Xport_protection_diode_121 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<107>
Xport_protection_diode_122 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<106>
Xport_protection_diode_123 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<105>
Xport_protection_diode_124 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<104>
Xport_protection_diode_125 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<103>
Xport_protection_diode_126 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<102>
Xport_protection_diode_127 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<101>
Xport_protection_diode_128 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<100>
Xport_protection_diode_129 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<99>
Xport_protection_diode_130 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<98>
Xport_protection_diode_131 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<97>
Xport_protection_diode_132 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<96>
Xport_protection_diode_133 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<95>
Xport_protection_diode_134 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<94>
Xport_protection_diode_135 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<93>
Xport_protection_diode_136 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<92>
Xport_protection_diode_137 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<91>
Xport_protection_diode_138 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<90>
Xport_protection_diode_139 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<89>
Xport_protection_diode_140 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<88>
Xport_protection_diode_141 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<87>
Xport_protection_diode_142 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<86>
Xport_protection_diode_143 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<85>
Xport_protection_diode_144 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<84>
Xport_protection_diode_145 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<83>
Xport_protection_diode_146 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<82>
Xport_protection_diode_147 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<81>
Xport_protection_diode_148 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<80>
Xport_protection_diode_149 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<79>
Xport_protection_diode_150 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<78>
Xport_protection_diode_151 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<77>
Xport_protection_diode_152 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<76>
Xport_protection_diode_153 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=p<75>
Xport_protection_diode_154 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<102>
Xport_protection_diode_155 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<101>
Xport_protection_diode_156 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<100>
Xport_protection_diode_157 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<99>
Xport_protection_diode_158 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<98>
Xport_protection_diode_159 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<97>
Xport_protection_diode_160 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<96>
Xport_protection_diode_161 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<95>
Xport_protection_diode_162 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<94>
Xport_protection_diode_163 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<93>
Xport_protection_diode_164 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<92>
Xport_protection_diode_165 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<91>
Xport_protection_diode_166 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<90>
Xport_protection_diode_167 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<89>
Xport_protection_diode_168 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<88>
Xport_protection_diode_169 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<87>
Xport_protection_diode_170 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<86>
Xport_protection_diode_171 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<85>
Xport_protection_diode_172 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<84>
Xport_protection_diode_173 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<83>
Xport_protection_diode_174 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<82>
Xport_protection_diode_175 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<81>
Xport_protection_diode_176 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<80>
Xport_protection_diode_177 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<79>
Xport_protection_diode_178 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<78>
Xport_protection_diode_179 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<77>
Xport_protection_diode_180 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<76>
Xport_protection_diode_181 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<75>
Xport_protection_diode_182 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<74>
Xport_protection_diode_183 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<73>
Xport_protection_diode_184 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<72>
Xport_protection_diode_185 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<71>
Xport_protection_diode_186 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<70>
Xport_protection_diode_187 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<69>
Xport_protection_diode_188 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<68>
Xport_protection_diode_189 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<67>
Xport_protection_diode_190 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<66>
Xport_protection_diode_191 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<65>
Xport_protection_diode_192 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<64>
Xport_protection_diode_193 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<63>
Xport_protection_diode_194 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<62>
Xport_protection_diode_195 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<61>
Xport_protection_diode_196 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<60>
Xport_protection_diode_197 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<59>
Xport_protection_diode_198 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<58>
Xport_protection_diode_199 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<57>
Xport_protection_diode_200 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<56>
Xport_protection_diode_201 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<55>
Xport_protection_diode_202 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<54>
Xport_protection_diode_203 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<53>
Xport_protection_diode_204 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<52>
Xport_protection_diode_205 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<51>
Xport_protection_diode_206 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<50>
Xport_protection_diode_207 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<49>
Xport_protection_diode_208 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<48>
Xport_protection_diode_209 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<47>
Xport_protection_diode_210 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<46>
Xport_protection_diode_211 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<45>
Xport_protection_diode_212 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<44>
Xport_protection_diode_213 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<43>
Xport_protection_diode_214 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<42>
Xport_protection_diode_215 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<41>
Xport_protection_diode_216 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<40>
Xport_protection_diode_217 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<39>
Xport_protection_diode_218 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<38>
Xport_protection_diode_219 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<37>
Xport_protection_diode_220 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<36>
Xport_protection_diode_221 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<35>
Xport_protection_diode_222 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<34>
Xport_protection_diode_223 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<33>
Xport_protection_diode_224 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<32>
Xport_protection_diode_225 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<31>
Xport_protection_diode_226 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<30>
Xport_protection_diode_227 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<29>
Xport_protection_diode_228 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<28>
Xport_protection_diode_229 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<27>
Xport_protection_diode_230 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<26>
Xport_protection_diode_231 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<25>
Xport_protection_diode_232 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=clk
Xport_protection_diode_233 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=reset_n
Xport_protection_diode_234 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<127>
Xport_protection_diode_235 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<126>
Xport_protection_diode_236 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<125>
Xport_protection_diode_237 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<124>
Xport_protection_diode_238 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<123>
Xport_protection_diode_239 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<122>
Xport_protection_diode_240 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<121>
Xport_protection_diode_241 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<120>
Xport_protection_diode_242 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<119>
Xport_protection_diode_243 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<118>
Xport_protection_diode_244 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<117>
Xport_protection_diode_245 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<116>
Xport_protection_diode_246 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<115>
Xport_protection_diode_247 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<114>
Xport_protection_diode_248 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<113>
Xport_protection_diode_249 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<112>
Xport_protection_diode_250 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<111>
Xport_protection_diode_251 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<110>
Xport_protection_diode_252 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<109>
Xport_protection_diode_253 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<108>
Xport_protection_diode_254 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<107>
Xport_protection_diode_255 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<106>
Xport_protection_diode_256 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<105>
Xicc_place1699 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n3854 I=n2333
Xicc_place1825 INVD5BWP7T $PINS VSS=VSS VDD=VDD ZN=n3980 I=n1528
Xicc_place1822 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n1681 ZN=n3977
Xicc_place1698 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3853 I=round<4>
Xicc_place1697 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n3852 I=n2313
Xicc_place1704 INVD6BWP7T $PINS VSS=VSS VDD=VDD ZN=n3859 I=n3858
Xicc_place1703 BUFFD4BWP7T $PINS VSS=VSS VDD=VDD Z=n3858 I=n3658
Xicc_place1997 INVD2P5BWP7T $PINS VSS=VSS VDD=VDD ZN=c<8> I=n3556
Xicc_place2060 CKND2BWP7T $PINS VDD=VDD VSS=VSS ZN=c<90> I=n3532
Xicc_place2022 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<102> ZN=n4177
Xicc_place1602 OA222D0BWP7T $PINS Z=n1152 B1=n2327 A1=n4054 A2=n2326 B2=n3861
+ C2=n3991 C1=n4128 VDD=VDD VSS=VSS
Xicc_place1605 INVD0BWP7T $PINS ZN=n4330 VSS=VSS VDD=VDD I=n1152
Xicc_place1705 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD I=n1752 Z=n4331
Xicc_place1734 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4332 I=n2125
Xicc_place1736 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4449 Z=n4333
Xicc_place1738 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<109> Z=n4334
Xicc_place1742 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<25> Z=n4335
Xicc_place1748 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<124> Z=n4396
Xicc_place1756 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1946 Z=n4373
Xicc_place1773 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4387 I=k<91>
Xicc_place1781 AO22D0BWP7T $PINS Z=n4336 A2=n4012 A1=n3750 B1=n4050 VDD=VDD
+ B2=n3943 VSS=VSS
Xicc_place1796 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4430 Z=n4352
Xicc_place1799 NR2XD3BWP7T $PINS VSS=VSS VDD=VDD A1=n3935 ZN=c<112> A2=n4006
Xicc_place1804 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<40> Z=n4393
Xicc_place1806 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4383 I=k<71>
Xicc_place1846 CKBD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4378 I=n4415
Xicc_place1858 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<16> Z=n4338
Xicc_place1867 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<28> Z=n4377
Xicc_place1868 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4339 I=n4417
Xicc_place1880 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4340 I=n4419
Xicc_place1903 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=rout<117> Z=n4341
Xicc_place2072 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4342 I=n4418
Xicc_place2073 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4343 I=n4422
Xicc_place2074 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4344 I=n4421
Xicc_place2075 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4345 I=n4424
Xicc_place2079 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4347 I=n4428
Xicc_place2081 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4348 I=n4425
Xicc_place2082 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4349 I=n4426
Xicc_place2083 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4350 I=n4427
Xicc_place2084 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=rout<96> Z=n4351
Xicc_place2085 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4353 I=n4432
Xicc_place2089 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4354 I=rout<103>
Xicc_place2090 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4355 I=n4431
Xicc_place2091 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4356 I=rout<54>
Xicc_place2095 AOI22D2BWP7T $PINS VSS=VSS VDD=VDD B2=n4270 A2=n2398 ZN=n4357
+ A1=n4098 B1=l<109>
Xicc_place2096 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4358 I=N122
Xicc_place2099 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4359 I=N120
Xicc_place2101 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4360 I=N107
Xicc_place2104 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4361 I=n2097
Xicc_place2105 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4362 I=n2090
Xicc_place2106 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4363 I=n2117
Xicc_place2110 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4364 I=n2129
Xicc_place2119 AOI22D1BWP7T $PINS ZN=n4365 A1=n4026 A2=n3882 B2=n3626 VDD=VDD
+ B1=l<19> VSS=VSS
Xicc_place2121 OA222D0BWP7T $PINS Z=n1074 B1=n2387 A1=n4054 A2=n2386 B2=n3861
+ C2=n3991 C1=n3924 VDD=VDD VSS=VSS
Xicc_place2123 INVD0BWP7T $PINS ZN=n4366 VSS=VSS VDD=VDD I=n1074
Xicc_place2124 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4367 I=n1108
Xicc_place2126 OA222D0BWP7T $PINS Z=n1092 B1=n2373 A1=n4055 A2=n2372 B2=n3857
+ C2=n3997 C1=n3926 VDD=VDD VSS=VSS
Xicc_place2138 INVD0BWP7T $PINS ZN=n4368 VSS=VSS VDD=VDD I=n1092
Xicc_place2140 OA222D0BWP7T $PINS Z=n1091 B1=n3355 A1=n4055 A2=n2373 B2=n3857
+ C2=n3997 C1=n3898 VDD=VDD VSS=VSS
Xicc_place2144 INVD0BWP7T $PINS ZN=n4369 VSS=VSS VDD=VDD I=n1091
Xicc_place2145 OA222D0BWP7T $PINS Z=n1142 B1=n2337 A1=n4055 A2=n2336 B2=n3857
+ C2=n3988 C1=n3942 VDD=VDD VSS=VSS
Xicc_place2146 INVD0BWP7T $PINS ZN=n4370 VSS=VSS VDD=VDD I=n1142
Xicc_place2147 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4371 I=n1643
Xicc_place2149 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4372 I=n3359
Xicc_place2150 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4374 I=n1651
Xicc_place2159 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4375 I=n3683
Xicc_place2160 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<35> Z=n4376
Xicc_place2161 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4451 Z=n4379
Xicc_place2162 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<11> Z=n4380
Xicc_place2163 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<12> Z=n4381
Xicc_place2164 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4382 I=k<67>
Xicc_place2165 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<72> Z=n4384
Xicc_place2166 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4454 Z=n4385
Xicc_place2167 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<88> Z=n4386
Xicc_place2168 DEL1BWP7T $PINS VSS=VSS VDD=VDD I=n4455 Z=n4388
Xicc_place2169 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4389 I=k<110>
Xicc_place2170 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<5> Z=n4390
Xicc_place2171 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<6> Z=n4391
Xicc_place2172 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4392 I=n4457
Xicc_place2173 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4450 Z=n4394
Xicc_place2174 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<121> Z=n4395
Xicc_place2175 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<17> Z=n4397
Xicc_place2176 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<45> Z=n4398
Xicc_place2177 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<50> Z=n4399
Xicc_place2178 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<52> Z=n4400
Xicc_place2179 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4452 Z=n4401
Xicc_place1739 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<60> ZN=n3894
Xicc_place1765 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3919 ZN=n3920
Xicc_place1556 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<9> Z=n3711
Xicc_place1757 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<44> ZN=n3912
Xicc_place1749 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<54> ZN=n3904
Xicc_place1771 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3925 ZN=n3926
Xicc_place1797 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<42> ZN=n3952
Xicc_place1777 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3931 ZN=n3932
Xicc_place1737 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<61> ZN=n3892
Xicc_place1722 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2382 Z=n3877
Xicc_place1896 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4051 I=n3679
Xicc_place1897 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4052 I=n3665
Xicc_place1899 BUFFD10BWP7T $PINS VSS=VSS VDD=VDD Z=n4054 I=n3665
Xicc_place1900 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n4055 I=n3665
Xicc_place1800 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<124> ZN=n3955
Xicc_place1835 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3989 ZN=n3990
Xicc_place1702 CKND4BWP7T $PINS VSS=VSS VDD=VDD I=n3856 ZN=n3857
Xicc_place1807 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<40> ZN=n3962
Xicc_place1775 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<118> ZN=n3930
Xicc_place1810 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3964 ZN=n3965
Xicc_place1805 INVD2BWP7T $PINS VDD=VDD VSS=VSS ZN=n3960 I=rin<41>
Xicc_place1833 INVD5BWP7T $PINS VSS=VSS VDD=VDD ZN=n3988 I=n3987
Xicc_place2028 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<100> ZN=n4183
Xicc_place1991 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4256 ZN=n4146
Xicc_place2011 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<122> ZN=n4166
Xicc_place2015 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<108> ZN=n4170
Xicc_place1986 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n4140 ZN=n4141
Xicc_place1745 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3899 ZN=n3900
Xicc_place1990 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<120> ZN=n4145
Xicc_place1735 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n3890 I=rin<63>
Xicc_place2023 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<101> ZN=n4178
Xicc_place1956 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<54> ZN=n4111
Xicc_place2016 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<45> ZN=n4171
Xicc_place1747 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3901 ZN=n3902
Xicc_place2019 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<105> ZN=n4174
Xicc_place2018 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<112> ZN=n4173
Xicc_place1832 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n3987 I=n3683
Xicc_place1988 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4142 ZN=n4143
Xicc_place2131 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4294 I=n4006
Xicc_place1985 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4140 I=rout<115>
Xicc_place2006 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4161 I=rout<123>
Xicc_place2009 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4164 I=rout<114>
Xicc_place2013 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4168 I=rout<107>
Xicc_place2027 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=rout<99> ZN=n4182
Xicc_place2094 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4256 I=rout<121>
Xicc_place1551 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4263 ZN=n4262
Xicc_place1857 CKND10BWP7T $PINS VSS=VSS VDD=VDD I=n4323 ZN=n4012
Xicc_place1987 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n4142 I=rout<106>
Xicc_place1964 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4119 I=rout<42>
Xicc_place2100 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rout<63> ZN=n4263
Xicc_place1850 CKND6BWP7T $PINS VSS=VSS I=n4004 VDD=VDD ZN=done
Xicc_place1860 INVD6BWP7T $PINS VSS=VSS VDD=VDD ZN=n4015 I=n4323
Xicc_place1788 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3943 I=rin<126>
Xicc_place1764 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3919 I=rin<127>
Xicc_place1783 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3938 I=rin<110>
Xicc_place1790 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3945 I=rin<62>
Xicc_place1746 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3901 I=rin<55>
Xicc_place1759 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3914 I=rin<39>
Xicc_place1755 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3910 I=rin<46>
Xicc_place1666 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3821 I=k<102>
Xicc_place1792 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3947 I=rin<47>
Xicc_place1725 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<87> Z=n3880
Xicc_place1688 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<127> Z=n3843
Xicc_place1717 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=l<71> Z=n3872
Xicc_place1674 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=k<110> ZN=n3829
Xicc_place1633 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3788 I=k<63>
Xicc_place1641 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3796 I=k<70>
Xicc_place1667 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3822 I=k<103>
Xicc_place1574 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3728 ZN=n3729
Xicc_place1585 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3740 I=k<23>
Xicc_place1595 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3750 I=k<30>
Xicc_place1613 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<47> Z=n3768
Xicc_place1675 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3830 I=k<111>
Xicc_place1682 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3837 I=k<119>
Xicc_place1653 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3808 I=k<94>
Xicc_place1631 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3786 I=k<62>
Xicc_place1644 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3799 I=k<79>
Xicc_place1687 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n3842 I=k<126>
Xicc_place1910 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4443 Z=n4065
Xicc_place1709 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3864 I=n2351
Xicc_place1583 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3738 I=k<22>
Xicc_place1573 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD I=k<14> Z=n3728
Xicc_place1575 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3730 I=k<15>
Xicc_place1619 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3774 I=k<54>
Xicc_place1621 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3776 I=k<55>
Xicc_place1794 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3949 I=rin<96>
Xicc_place1728 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3883 I=n2353
Xicc_place1597 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=k<31> Z=n3752
Xicc_place1711 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2335 Z=n3866
Xicc_place1874 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3567 ZN=c<48>
Xicc_place1881 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<108> I=n3131
Xicc_place1877 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3564 ZN=c<120>
Xicc_place1875 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<119> I=n3566
Xicc_place2005 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4347 ZN=c<26>
Xicc_place2053 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<87> I=n4249
Xicc_place2051 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=c<67> I=n4339
Xicc_place2050 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=c<66> I=n4240
Xicc_place2049 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3511 ZN=c<77>
Xicc_place2048 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<73> I=n3514
Xicc_place2054 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<78> I=n4254
Xicc_place2055 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<72> I=n3560
Xicc_place2056 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3554 ZN=c<70>
Xicc_place2047 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3520 ZN=c<64>
Xicc_place2057 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3551 ZN=c<75>
Xicc_place2046 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<95> I=n3521
Xicc_place2045 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=c<79> I=n3528
Xicc_place2044 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<94> I=n3530
Xicc_place2043 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<11> I=n3539
Xicc_place2042 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<71> I=n3541
Xicc_place2041 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3544 ZN=c<83>
Xicc_place2058 INVD3BWP7T $PINS VDD=VDD VSS=VSS ZN=c<65> I=n3545
Xicc_place2039 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<86> I=n3557
Xicc_place2037 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<27> I=n4343
Xicc_place2036 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<30> I=n4250
Xicc_place2035 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=c<74> I=n4342
Xicc_place2034 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<88> I=n3513
Xicc_place2033 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<16> I=n3516
Xicc_place2032 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<14> I=n3522
Xicc_place2031 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3547 ZN=c<19>
Xicc_place2030 INVD3BWP7T $PINS VDD=VDD VSS=VSS ZN=c<12> I=n3550
Xicc_place2029 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<24> I=n3553
Xicc_place2004 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<28> I=n4248
Xicc_place2003 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=c<10> I=n4349
Xicc_place2002 CKND2BWP7T $PINS VSS=VSS I=n3507 VDD=VDD ZN=c<7>
Xicc_place2001 CKND2BWP7T $PINS VSS=VSS I=n3508 VDD=VDD ZN=c<0>
Xicc_place2000 CKND2BWP7T $PINS VSS=VSS I=n3512 VDD=VDD ZN=c<6>
Xicc_place1999 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3519 ZN=c<25>
Xicc_place1998 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3536 ZN=c<23>
Xicc_place1984 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4259 ZN=c<21>
Xicc_place1983 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=c<9> I=n4344
Xicc_place1982 INVD3BWP7T $PINS VDD=VDD VSS=VSS ZN=c<1> I=n3537
Xicc_place1981 CKND2BWP7T $PINS VSS=VSS I=n3540 VDD=VDD ZN=c<4>
Xicc_place1980 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<22> I=n3548
Xicc_place1979 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3559 ZN=c<18>
Xicc_place1972 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4353 ZN=c<31>
Xicc_place1971 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=c<15> I=n4355
Xicc_place1970 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=c<2> I=n4348
Xicc_place1969 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<5> I=n3518
Xicc_place1961 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=c<17> I=n4352
Xicc_place2040 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3552 ZN=c<20>
Xicc_place2071 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3509 ZN=c<80>
Xicc_place2059 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3538 ZN=c<13>
Xicc_place2061 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<91> I=n3527
Xicc_place2062 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3526 ZN=c<89>
Xicc_place2063 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3525 ZN=c<84>
Xicc_place2064 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<69> I=n3523
Xicc_place2065 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<29> I=n3515
Xicc_place2068 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=c<93> I=n3558
Xicc_place2069 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3546 ZN=c<85>
Xicc_place2066 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<68> I=n2844
Xicc_place2052 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=c<81> I=n4340
Xicc_place2067 INVD3BWP7T $PINS VSS=VSS VDD=VDD ZN=c<92> I=n4242
Xicc_place1902 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3135 ZN=c<55>
Xicc_place2070 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=c<76> I=n3524
Xicc_place1564 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3719 I=p<49>
Xicc_place1566 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3721 I=p<58>
Xicc_place1561 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=p<38> Z=n3716
Xicc_place1560 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3715 I=p<36>
Xicc_place1567 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3722 I=p<97>
Xicc_place1565 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=p<55> Z=n3720
Xicc_place1558 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3713 I=p<33>
Xicc_place1563 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3718 I=p<48>
Xicc_place1562 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD I=p<44> Z=n3717
Xicc_place1559 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3714 I=p<34>
Xicc_place1694 AO22D2BWP7T $PINS VSS=VSS VDD=VDD Z=n4227 A1=n3802 A2=n4014
+ B1=n4049 B2=rin<49>
Xicc_place1924 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2041 Z=n4079
Xicc_place1901 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n4055 ZN=n4056
Xicc_place1922 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2127 Z=n4077
Xicc_place1921 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n2002 Z=n4076
Xicc_place1898 INVD4BWP7T $PINS VSS=VSS VDD=VDD ZN=n4053 I=n4052
Xicc_place1789 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3943 ZN=n3944
Xicc_place1811 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<49> ZN=n3966
Xicc_place1753 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3908 I=n3907
Xicc_place1782 INVD2P5BWP7T $PINS VDD=VDD VSS=VSS ZN=n3937 I=rin<111>
Xicc_place1769 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3923 ZN=n3924
Xicc_place1553 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3708 I=p<2>
Xicc_place1751 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3905 ZN=n3906
Xicc_place1787 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<125> ZN=n3942
Xicc_place1793 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3947 ZN=n3948
Xicc_place1554 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3709 I=p<4>
Xicc_place1743 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=rin<57> ZN=n3898
Xicc_place1555 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3710 I=p<5>
Xicc_place1992 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4147 I=rout<104>
Xicc_place1993 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4148 I=rout<118>
Xicc_place1994 INVD0BWP7T $PINS ZN=n4149 VSS=VSS VDD=VDD I=n4429
Xicc_place1995 INVD0BWP7T $PINS ZN=n4150 VSS=VSS VDD=VDD I=rout<110>
Xicc_place1996 INVD0BWP7T $PINS ZN=n4151 VSS=VSS VDD=VDD I=n4354
Xicc_place2007 INVD0BWP7T $PINS ZN=n4162 VSS=VSS VDD=VDD I=n4161
Xicc_place2008 INVD0BWP7T $PINS ZN=n4163 VSS=VSS VDD=VDD I=rout<124>
Xicc_place2010 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4165 I=n4164
Xicc_place2012 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4167 I=rout<98>
Xicc_place2014 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4169 I=n4168
Xicc_place2017 INVD0BWP7T $PINS ZN=n4172 VSS=VSS VDD=VDD I=rout<127>
Xicc_place2020 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4175 I=rout<111>
Xicc_place2021 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4176 I=rout<113>
Xicc_place2024 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4179 I=rout<109>
Xicc_place2025 INVD0BWP7T $PINS ZN=n4180 VSS=VSS VDD=VDD I=rout<61>
Xicc_place2026 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4181 I=rout<116>
Xicc_place2038 INVD0BWP7T $PINS ZN=n4193 VSS=VSS VDD=VDD I=n4341
Xicc_place1849 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4004 I=n3671
Xicc_place1552 BUFFD2BWP7T $PINS VSS=VSS VDD=VDD Z=n3707 I=start
Xicc_place1689 BUFFD10BWP7T $PINS VSS=VSS VDD=VDD Z=n3844 I=reset_n
Xicc_place1701 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3856 I=n3658
Xicc_place1862 INVD6BWP7T $PINS VSS=VSS VDD=VDD ZN=n4017 I=n4016
Xicc_place1848 AN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=c<46> A1=n3910 A2=done
Xicc_place1852 AN2D2BWP7T $PINS VSS=VSS VDD=VDD Z=c<97> A1=n3888 A2=done
Xicc_place1864 AO21D0BWP7T $PINS Z=n4231 B=n4227 A1=n2124 VDD=VDD A2=n3989
+ VSS=VSS
Xicc_place1904 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<78> Z=n4309
Xicc_place1905 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<12> Z=n4302
Xicc_place1923 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<8> Z=n4301
Xicc_place2076 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4238 I=n4420
Xicc_place2078 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4240 I=n4416
Xicc_place2080 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4242 I=n3555
Xicc_place2086 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4248 I=n2871
Xicc_place2087 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4249 I=n3535
Xicc_place2088 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4250 I=n3533
Xicc_place2092 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4254 I=n3549
Xicc_place2093 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4255 I=n4423
Xicc_place2097 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4259 I=n4350
Xicc_place2098 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4260 I=rout<40>
Xicc_place2102 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4265 I=n1770
Xicc_place2103 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4266 I=n1744
Xicc_place2108 INVD1BWP7T $PINS VDD=VDD VSS=VSS I=n3629 ZN=n4271
Xicc_place2109 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4272 I=n2014
Xicc_place2111 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4274 I=n2103
Xicc_place2112 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4275 I=n2094
Xicc_place2113 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4276 I=n2087
Xicc_place2114 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4277 I=n2084
Xicc_place2115 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4278 I=n4364
Xicc_place2116 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4279 I=n4438
Xicc_place2117 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4280 I=n4365
Xicc_place2118 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4281 I=n1812
Xicc_place2120 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4283 I=n1120
Xicc_place2122 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4285 I=n1104
Xicc_place2125 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4288 I=n1160
Xicc_place2127 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4290 I=n4444
Xicc_place2128 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4291 I=n1670
Xicc_place2129 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n1828 Z=n4292
Xicc_place2130 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4293 I=n3671
Xicc_place2132 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4295 I=n1343
Xicc_place2133 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4296 I=n1397
Xicc_place2134 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<37> Z=n4297
Xicc_place2135 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<40> Z=n4298
Xicc_place2137 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<52> Z=n4300
Xicc_place2139 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<34> Z=n4304
Xicc_place2141 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<73> Z=n4307
Xicc_place2142 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<76> Z=n4308
Xicc_place2143 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<87> Z=n4310
Xicc_place2148 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<8> Z=n4315
Xicc_place2151 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4335 Z=n4318
Xicc_place2152 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<18> Z=n4319
Xicc_place2153 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<42> Z=n4320
Xicc_place2154 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4461 Z=n4321
Xicc_place2155 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4322 I=n1613
Xicc_place2157 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4328 I=k<82>
Xicc_place2136 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4299 I=p<51>
Xicc_place1863 CKAN2D2BWP7T $PINS VSS=VSS A1=n3868 VDD=VDD A2=done Z=c<33>
Xicc_place1851 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4006 I=n3671
Xicc_place2156 BUFFD3BWP7T $PINS VSS=VSS I=n3630 VDD=VDD Z=n4323
Xicc_place1866 INVD8BWP7T $PINS VSS=VSS VDD=VDD I=n4020 ZN=n4021
Xicc_place1865 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n4020 I=n3643
Xicc_place1944 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=N100 Z=n4099
Xicc_place1945 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4100 I=N125
Xicc_place1946 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=n4360 Z=n4101
Xicc_place1947 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=N103 Z=n4102
Xicc_place1691 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3846 I=n3844
Xicc_place1693 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n3848 I=n3844
Xicc_place1695 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n3850 I=n3844
Xicc_place1690 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n3845 I=n3844
Xicc_place1692 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3847 I=n3844
Xicc_place1696 BUFFD5BWP7T $PINS VSS=VSS VDD=VDD Z=n3851 I=n3844
Xicc_place1879 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3562 ZN=c<63>
Xicc_place1876 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3565 ZN=c<116>
Xicc_place1878 INVD2BWP7T $PINS VSS=VSS VDD=VDD I=n3563 ZN=c<56>
Xicc_place1634 INVD0BWP7T $PINS ZN=n3789 VSS=VSS VDD=VDD I=n3788
Xicc_place1636 INVD0BWP7T $PINS ZN=n3791 VSS=VSS VDD=VDD I=n3790
Xicc_place1638 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3793 I=n3792
Xicc_place1640 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3795 I=n3794
Xicc_place1645 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3800 I=n3799
Xicc_place1654 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3809 I=n3808
Xicc_place1669 CKBD2BWP7T $PINS VSS=VSS VDD=VDD I=k<105> Z=n3824
Xicc_place1672 INVD0BWP7T $PINS ZN=n3827 VSS=VSS VDD=VDD I=n3826
Xicc_place1707 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3862 I=n2390
Xicc_place1741 INVD2BWP7T $PINS VSS=VSS VDD=VDD ZN=n3896 I=n3895
Xicc_place1752 BUFFD1P5BWP7T $PINS VSS=VSS I=rin<50> VDD=VDD Z=n3907
Xicc_place1754 CKND2BWP7T $PINS VSS=VSS I=rin<48> VDD=VDD ZN=n3909
Xicc_place1767 CKND2BWP7T $PINS VSS=VSS I=n3921 VDD=VDD ZN=n3922
Xicc_place1772 CKND2BWP7T $PINS VSS=VSS I=rin<120> VDD=VDD ZN=n3927
Xicc_place1774 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3929 I=rin<119>
Xicc_place1780 CKND2BWP7T $PINS VSS=VSS I=n3934 VDD=VDD ZN=n3935
Xicc_place1791 CKND2BWP7T $PINS VSS=VSS I=n3945 VDD=VDD ZN=n3946
Xicc_place1795 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3950 I=n3949
Xicc_place1802 CKND2BWP7T $PINS VSS=VSS I=n3956 VDD=VDD ZN=n3957
Xicc_place1812 INVD2BWP7T $PINS VDD=VDD VSS=VSS ZN=n3967 I=n1612
Xicc_place1813 CKND2BWP7T $PINS VSS=VSS I=n1759 VDD=VDD ZN=n3968
Xicc_place1814 CKND2BWP7T $PINS VSS=VSS I=n1723 VDD=VDD ZN=n3969
Xicc_place1819 CKND2BWP7T $PINS VSS=VSS I=n1409 VDD=VDD ZN=n3974
Xicc_place1820 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3975 I=n1407
Xicc_place1821 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3976 I=n1584
Xicc_place1826 CKND2BWP7T $PINS VSS=VSS I=n1754 VDD=VDD ZN=n3981
Xicc_place1831 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3986 I=n2307
Xicc_place1836 CKND10BWP7T $PINS VSS=VSS VDD=VDD I=n4375 ZN=n3991
Xicc_place1837 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3992 I=n3683
Xicc_place1838 CKND8BWP7T $PINS VSS=VSS I=n3992 VDD=VDD ZN=n3993
Xicc_place1839 BUFFD8BWP7T $PINS VSS=VSS VDD=VDD Z=n3994 I=n3683
Xicc_place1840 CKND8BWP7T $PINS VSS=VSS I=n3994 VDD=VDD ZN=n3995
Xicc_place1841 BUFFD3BWP7T $PINS VSS=VSS I=n3683 VDD=VDD Z=n3996
Xicc_place1842 INVD6BWP7T $PINS VSS=VSS I=n3996 VDD=VDD ZN=n3997
Xicc_place1845 BUFFD6BWP7T $PINS VSS=VSS VDD=VDD Z=n4000 I=n3653
Xicc_place1847 BUFFD12BWP7T $PINS VDD=VDD VSS=VSS I=n3671 Z=n4002
Xicc_place1855 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4010 I=n1946
Xicc_place1859 CKND10BWP7T $PINS VSS=VSS VDD=VDD ZN=n4014 I=n4323
Xicc_place1869 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4024 I=n1828
Xicc_place1871 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4026 I=n3626
Xicc_place1886 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4041 I=n1485
Xicc_place1890 INVD2BWP7T $PINS VSS=VSS VDD=VDD ZN=n4045 I=n3617
Xicc_place1907 INVD0BWP7T $PINS ZN=n4062 VSS=VSS VDD=VDD I=n4061
Xicc_place1911 INVD0BWP7T $PINS ZN=n4066 VSS=VSS VDD=VDD I=n1907
Xicc_place1912 INVD0BWP7T $PINS ZN=n4067 VSS=VSS VDD=VDD I=n1580
Xicc_place1913 INVD0BWP7T $PINS ZN=n4068 VSS=VSS VDD=VDD I=n1958
Xicc_place1914 INVD0BWP7T $PINS ZN=n4069 VSS=VSS VDD=VDD I=n1467
Xicc_place1915 INVD0BWP7T $PINS ZN=n4070 VSS=VSS VDD=VDD I=n1815
Xicc_place1916 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4071 I=n3585
Xicc_place1919 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4074 I=n1783
Xicc_place1920 INVD0BWP7T $PINS ZN=n4075 VSS=VSS VDD=VDD I=n1492
Xicc_place1925 INVD0BWP7T $PINS ZN=n4080 VSS=VSS VDD=VDD I=n1826
Xicc_place1926 INVD0BWP7T $PINS ZN=n4081 VSS=VSS VDD=VDD I=n1706
Xicc_place1927 INVD0BWP7T $PINS ZN=n4082 VSS=VSS VDD=VDD I=n1871
Xicc_place1928 INVD0BWP7T $PINS ZN=n4083 VSS=VSS VDD=VDD I=n1484
Xicc_place1929 INVD0BWP7T $PINS ZN=n4084 VSS=VSS VDD=VDD I=n1883
Xicc_place1930 INVD0BWP7T $PINS ZN=n4085 VSS=VSS VDD=VDD I=n1918
Xicc_place1931 INVD0BWP7T $PINS ZN=n4086 VSS=VSS VDD=VDD I=n1793
Xicc_place1932 INVD0BWP7T $PINS ZN=n4087 VSS=VSS VDD=VDD I=n1714
Xicc_place1933 INVD0BWP7T $PINS ZN=n4088 VSS=VSS VDD=VDD I=n1849
Xicc_place1934 INVD0BWP7T $PINS ZN=n4089 VSS=VSS VDD=VDD I=n1548
Xicc_place1935 INVD0BWP7T $PINS ZN=n4090 VSS=VSS VDD=VDD I=n1451
Xicc_place1936 INVD0BWP7T $PINS ZN=n4091 VSS=VSS VDD=VDD I=n1611
Xicc_place1937 INVD0BWP7T $PINS ZN=n4092 VSS=VSS VDD=VDD I=n1973
Xicc_place1938 INVD0BWP7T $PINS ZN=n4093 VSS=VSS VDD=VDD I=n1459
Xicc_place1939 INVD0BWP7T $PINS ZN=n4094 VSS=VSS VDD=VDD I=n1744
Xicc_place1940 INVD0BWP7T $PINS ZN=n4095 VSS=VSS VDD=VDD I=n1944
Xicc_place1941 INVD0BWP7T $PINS ZN=n4096 VSS=VSS VDD=VDD I=n1837
Xicc_place1942 INVD0BWP7T $PINS ZN=n4097 VSS=VSS VDD=VDD I=n1804
Xicc_place1948 INVD0BWP7T $PINS ZN=n4103 VSS=VSS VDD=VDD I=n1722
Xicc_place1949 INVD0BWP7T $PINS ZN=n4104 VSS=VSS VDD=VDD I=n1896
Xicc_place1950 INVD0BWP7T $PINS ZN=n4105 VSS=VSS VDD=VDD I=n1860
Xicc_place1951 INVD0BWP7T $PINS ZN=n4106 VSS=VSS VDD=VDD I=n1782
Xicc_place1952 INVD0BWP7T $PINS ZN=n4107 VSS=VSS VDD=VDD I=n1752
Xicc_place1954 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4109 I=rout<49>
Xicc_place1955 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4110 I=rout<33>
Xicc_place1957 INVD0BWP7T $PINS ZN=n4112 VSS=VSS VDD=VDD I=rout<37>
Xicc_place1958 INVD0BWP7T $PINS ZN=n4113 VSS=VSS VDD=VDD I=rout<53>
Xicc_place1959 INVD0BWP7T $PINS ZN=n4114 VSS=VSS VDD=VDD I=rout<38>
Xicc_place1960 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4115 I=n4465
Xicc_place1962 INVD0BWP7T $PINS ZN=n4117 VSS=VSS VDD=VDD I=rout<60>
Xicc_place1963 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4118 I=rout<36>
Xicc_place1965 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n4120 I=n4119
Xicc_place1966 INVD0BWP7T $PINS ZN=n4121 VSS=VSS VDD=VDD I=rout<44>
Xicc_place1967 INVD0BWP7T $PINS ZN=n4122 VSS=VSS VDD=VDD I=rout<32>
Xicc_place1968 INVD0BWP7T $PINS ZN=n4123 VSS=VSS VDD=VDD I=rout<39>
Xicc_place1973 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4128 I=rout<43>
Xicc_place1974 INVD0BWP7T $PINS ZN=n4129 VSS=VSS VDD=VDD I=rout<52>
Xicc_place1975 INVD0BWP7T $PINS ZN=n4130 VSS=VSS VDD=VDD I=rout<46>
Xicc_place1976 INVD0BWP7T $PINS ZN=n4131 VSS=VSS VDD=VDD I=rout<56>
Xicc_place1977 INVD0BWP7T $PINS ZN=n4132 VSS=VSS VDD=VDD I=rout<62>
Xicc_place1978 INVD0BWP7T $PINS ZN=n4133 VSS=VSS VDD=VDD I=rout<48>
Xicc_place1989 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n4144 I=rout<35>
Xicc_place1557 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n3712 I=p<23>
Xicc_place1569 INVD1BWP7T $PINS VSS=VSS I=k<1> VDD=VDD ZN=n3724
Xicc_place1570 CKND2BWP7T $PINS VSS=VSS I=k<7> VDD=VDD ZN=n3725
Xicc_place1572 INVD0BWP7T $PINS ZN=n3727 VSS=VSS VDD=VDD I=n3726
Xicc_place1576 CKND0BWP7T $PINS VSS=VSS VDD=VDD ZN=n3731 I=n3730
Xicc_place1578 INVD0BWP7T $PINS ZN=n3733 VSS=VSS VDD=VDD I=n3732
Xicc_place1580 INVD0BWP7T $PINS ZN=n3735 VSS=VSS VDD=VDD I=n3734
Xicc_place1582 INVD0BWP7T $PINS ZN=n3737 VSS=VSS VDD=VDD I=n3736
Xicc_place1584 INVD0BWP7T $PINS ZN=n3739 VSS=VSS VDD=VDD I=n3738
Xicc_place1586 INVD0BWP7T $PINS ZN=n3741 VSS=VSS VDD=VDD I=n3740
Xicc_place1588 INVD0BWP7T $PINS ZN=n3743 VSS=VSS VDD=VDD I=n3742
Xicc_place1590 INVD0BWP7T $PINS ZN=n3745 VSS=VSS VDD=VDD I=n3744
Xicc_place1592 INVD0BWP7T $PINS ZN=n3747 VSS=VSS VDD=VDD I=n3746
Xicc_place1594 INVD0BWP7T $PINS ZN=n3749 VSS=VSS VDD=VDD I=n3748
Xicc_place1596 INVD0BWP7T $PINS ZN=n3751 VSS=VSS VDD=VDD I=n3750
Xicc_place1598 INVD0BWP7T $PINS ZN=n3753 VSS=VSS VDD=VDD I=n3752
Xicc_place1600 INVD0BWP7T $PINS ZN=n3755 VSS=VSS VDD=VDD I=n3754
Xicc_place1601 CKND1BWP7T $PINS VSS=VSS VDD=VDD ZN=n3756 I=k<34>
Xicc_place1607 CKBD2BWP7T $PINS VSS=VSS VDD=VDD I=k<41> Z=n3762
Xicc_place1608 INVD0BWP7T $PINS ZN=n3763 VSS=VSS VDD=VDD I=n3762
Xicc_place1610 INVD0BWP7T $PINS ZN=n3765 VSS=VSS VDD=VDD I=n3764
Xicc_place1612 INVD0BWP7T $PINS ZN=n3767 VSS=VSS VDD=VDD I=n3766
Xicc_place1614 INVD0BWP7T $PINS ZN=n3769 VSS=VSS VDD=VDD I=n3768
Xicc_place1616 INVD0BWP7T $PINS ZN=n3771 VSS=VSS VDD=VDD I=n3770
Xicc_place1618 INVD0BWP7T $PINS ZN=n3773 VSS=VSS VDD=VDD I=n3772
Xicc_place1620 INVD0BWP7T $PINS ZN=n3775 VSS=VSS VDD=VDD I=n3774
Xicc_place1622 INVD0BWP7T $PINS ZN=n3777 VSS=VSS VDD=VDD I=n3776
Xicc_place1624 INVD0BWP7T $PINS ZN=n3779 VSS=VSS VDD=VDD I=n3778
Xicc_place1626 INVD0BWP7T $PINS ZN=n3781 VSS=VSS VDD=VDD I=n3780
Xicc_place1628 INVD0BWP7T $PINS ZN=n3783 VSS=VSS VDD=VDD I=n3782
Xicc_place1630 INVD0BWP7T $PINS ZN=n3785 VSS=VSS VDD=VDD I=n3784
Xicc_place1632 INVD0BWP7T $PINS ZN=n3787 VSS=VSS VDD=VDD I=n3786
Xport_protection_diode_257 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<104>
Xport_protection_diode_258 ANTENNABWP7T $PINS VSS=VSS VDD=VDD I=k<103>
Xicc_clock1551 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4414 I=n4441
Xicc_clock1552 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<26> Z=n4415
Xicc_clock1553 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<26> Z=n4449
Xicc_clock1554 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4416 I=n2758
Xicc_clock1555 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4417 I=n2757
Xicc_clock1556 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4418 I=n2755
Xicc_clock1557 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4419 I=n2754
Xicc_clock1558 OA222D0BWP7T $PINS Z=n1114 B1=n2360 A1=n4054 A2=n2359 B2=n3854
+ C2=n3991 C1=n4177 VDD=VDD VSS=VSS
Xicc_clock1559 INVD0BWP7T $PINS ZN=n4420 VSS=VSS VDD=VDD I=n1114
Xicc_clock1560 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4421 I=n2763
Xicc_clock1561 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4422 I=n3543
Xicc_clock1562 OA222D0BWP7T $PINS Z=n1065 B1=n2393 A1=n4054 A2=n2392 B2=n3861
+ C2=n3993 C1=n2702 VDD=VDD VSS=VSS
Xicc_clock1563 INVD0BWP7T $PINS ZN=n4423 VSS=VSS VDD=VDD I=n1065
Xicc_clock1564 OA222D0BWP7T $PINS Z=n1050 B1=n2405 A1=n4055 A2=n2404 B2=n3857
+ C2=n3995 C1=n4131 VDD=VDD VSS=VSS
Xicc_clock1565 INVD0BWP7T $PINS ZN=n4424 VSS=VSS VDD=VDD I=n1050
Xicc_clock1566 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4425 I=n2764
Xicc_clock1567 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4426 I=n2762
Xicc_clock1568 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4427 I=n3534
Xicc_clock1569 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4428 I=n3531
Xicc_clock1570 BUFFD3BWP7T $PINS VSS=VSS VDD=VDD Z=n4429 I=rout<119>
Xicc_clock1571 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4430 I=n2760
Xicc_clock1572 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4431 I=n2761
Xicc_clock1573 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4432 I=n3517
Xicc_clock1574 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4433 I=n1971
Xicc_clock1575 BUFFD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4434 I=n1896
Xicc_clock1576 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4435 I=n1276
Xicc_clock1577 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4436 I=n2008
Xicc_clock1578 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4437 I=n2100
Xicc_clock1579 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4438 I=n2121
Xicc_clock1580 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4439 I=n1801
Xicc_clock1581 INVD0BWP7T $PINS ZN=n4440 VSS=VSS VDD=VDD I=n1090
Xicc_clock1582 INVD0BWP7T $PINS ZN=n4441 VSS=VSS VDD=VDD I=n4440
Xicc_clock1583 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4442 I=n1539
Xicc_clock1584 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4443 I=n3363
Xicc_clock1585 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4444 I=n1806
Xicc_clock1586 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4445 I=n1371
Xicc_clock1587 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4446 I=p<32>
Xicc_clock1588 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=p<41> Z=n4447
Xicc_clock1589 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4448 I=p<43>
Xicc_clock1590 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<118> Z=n4450
Xicc_clock1591 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4451 I=k<4>
Xicc_clock1592 DEL1BWP7T $PINS VSS=VSS VDD=VDD I=k<60> Z=n4452
Xicc_clock1593 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4453 I=k<66>
Xicc_clock1594 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4454 I=k<86>
Xicc_clock1595 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<95> Z=n4455
Xicc_clock1596 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<3> Z=n4456
Xicc_clock1597 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<13> Z=n4457
Xicc_clock1598 BUFFD1BWP7T $PINS VSS=VSS VDD=VDD Z=n4458 I=k<46>
Xicc_clock1599 CKBD1BWP7T $PINS VSS=VSS VDD=VDD I=k<57> Z=n4459
Xicc_clock1600 BUFFD1P5BWP7T $PINS VSS=VSS VDD=VDD Z=n4460 I=k<74>
Xicc_clock1601 CKBD0BWP7T $PINS VSS=VSS VDD=VDD Z=n4461 I=k<74>
XCTSCKND12BWP7T_G1B1I2 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G1B4I2
+ I=clk_G1B1I1
XCTSCKND12BWP7T_G1B1I4 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G1B4I4
+ I=clk_G1B1I1
XCTSCKND12BWP7T_G1B3I1_1 INVD10BWP7T $PINS VSS=VSS I=clk VDD=VDD ZN=clk_G1B1I1
XCTSCKND10BWP7T_G1B1I3 CKND12BWP7T $PINS VSS=VSS VDD=VDD ZN=clk_G1B4I3
+ I=clk_G1B1I1
XCTSCKND6BWP7T_G1B1I1 INVD8BWP7T $PINS VSS=VSS VDD=VDD I=clk_G1B1I1
+ ZN=clk_G1B4I1
Xxofiller_DCAP32BWP7T_1 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_2 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_3 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_5 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_7 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_8 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_9 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_10 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_11 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_12 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_15 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_17 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_18 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_19 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_20 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_21 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_25 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_29 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_33 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_36 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_37 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_39 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_43 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_44 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP32BWP7T_45 DCAP32BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_1 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_2 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_3 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_4 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_5 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_6 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_8 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_9 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_12 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_15 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_17 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_18 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_19 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_21 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_22 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_23 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_24 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_25 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_26 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_27 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_28 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_29 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_31 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_32 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_33 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_39 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_40 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_41 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_42 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_44 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_45 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_49 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_50 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_51 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_52 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_53 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_54 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_57 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_58 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_60 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_61 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_62 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_63 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_64 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_65 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_66 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_67 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_68 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_70 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_72 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_73 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_74 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_77 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_78 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_79 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_81 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_86 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_88 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_89 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_90 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_91 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_92 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_93 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_94 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_95 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_97 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_98 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_99 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_100 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_101 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_102 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_106 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_107 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_109 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_114 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_115 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_116 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_117 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_118 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_122 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_123 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_124 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_125 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_127 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_129 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_131 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_133 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_136 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_137 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_138 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_141 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_142 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_143 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_146 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_147 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_151 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_152 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_156 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_157 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_162 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_163 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_164 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_166 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_167 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_172 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_174 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_175 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_176 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_177 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_179 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_180 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_181 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_182 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_188 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_190 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_192 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_193 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_199 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_201 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_202 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_203 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_206 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_207 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_208 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_212 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_216 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_217 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_223 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_224 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_225 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_226 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_229 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_230 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_231 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_234 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_236 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_238 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_241 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_244 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_247 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_248 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_249 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_252 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_257 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_258 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_259 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_262 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_268 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_269 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_270 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_274 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_275 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_281 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_282 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_284 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_286 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_287 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_288 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_292 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_295 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_296 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_299 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_302 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_304 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_309 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_313 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_314 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_315 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_316 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_320 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_324 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_326 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_329 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_336 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_337 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_338 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_339 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_341 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_342 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_344 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_345 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_349 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_351 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_354 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_356 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_357 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_360 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_361 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_362 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_364 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_366 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_367 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_368 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_370 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_372 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_374 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_377 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_381 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_383 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_386 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_387 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_389 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_390 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_393 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_394 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_396 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_399 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_400 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_401 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_403 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_409 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_410 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_411 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_412 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_413 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_414 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_415 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_416 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_417 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_418 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_419 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_421 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_422 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_423 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_425 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_428 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_429 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_430 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_431 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_432 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_434 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_435 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_436 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_438 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_439 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_441 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_442 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_443 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_446 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_449 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_450 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_451 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_452 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_453 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_455 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_456 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_457 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_459 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_460 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_461 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_462 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_463 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_464 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_465 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_467 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_469 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP16BWP7T_470 DCAP16BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_3 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_4 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_5 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_10 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_11 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_12 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_14 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_15 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_16 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_17 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_18 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_19 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_20 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_21 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_23 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_24 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_25 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_27 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_28 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_29 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_30 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_31 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_32 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_33 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_36 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_37 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_38 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_39 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_40 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_41 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_42 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_43 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_44 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_46 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_47 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_50 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_51 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_54 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_55 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_56 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_57 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_58 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_59 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_61 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_62 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_65 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_67 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_68 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_70 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_71 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_72 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_73 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_75 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_76 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_77 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_78 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_80 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_81 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_82 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_84 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_86 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_87 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_88 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_89 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_90 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_91 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_92 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_94 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_95 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_99 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_100 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_101 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_102 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_103 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_104 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_105 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_106 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_108 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_109 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_110 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_111 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_112 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_113 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_114 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_115 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_116 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_121 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_123 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_124 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_125 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_128 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_129 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_131 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_134 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_136 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_137 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_139 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_140 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_142 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_143 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_144 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_145 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_146 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_147 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_149 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_152 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_153 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_154 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_155 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_156 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_157 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_158 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_159 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_161 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_162 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_165 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_166 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_167 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_169 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_170 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_172 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_173 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_174 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_183 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_184 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_186 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_187 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_188 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_190 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_191 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_194 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_195 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_196 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_197 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_199 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_200 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_201 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_202 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_203 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_204 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_205 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_210 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_212 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_213 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_214 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_216 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_218 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_219 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_220 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_224 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_225 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_228 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_229 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_230 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_231 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_232 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_233 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_234 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_235 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_236 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_237 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_239 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_240 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_244 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_247 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_248 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_249 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_251 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_252 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_255 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_256 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_257 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_258 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_261 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_263 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_264 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_265 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_266 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_267 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_269 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_270 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_272 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_273 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_275 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_276 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_277 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_278 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_280 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_281 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_285 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_286 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_288 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_289 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_290 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_293 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_295 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_297 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_300 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_302 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_303 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_304 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_308 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_311 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_312 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_313 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_314 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_317 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_318 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_319 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_320 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_321 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_323 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_324 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_327 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_329 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_330 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_331 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_332 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_334 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_335 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_337 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_338 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_339 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_341 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_343 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_345 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_346 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_347 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_348 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_349 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_351 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_354 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_355 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_356 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_358 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_360 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_362 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_363 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_364 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_365 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_366 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_368 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_369 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_370 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_371 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_372 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_373 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_374 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_376 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_377 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_378 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_379 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_380 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_382 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_384 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_385 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_386 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_387 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_388 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_391 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_392 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_394 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_397 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_398 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_404 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_405 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_406 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_407 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_409 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_410 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_412 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_413 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_414 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_415 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_417 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_420 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_423 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_424 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_427 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_428 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_430 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_431 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_432 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_433 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_435 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_436 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_437 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_438 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_440 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_441 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_442 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_445 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_446 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_447 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_448 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_449 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_450 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_452 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_453 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_454 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_456 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_457 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_459 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_461 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_464 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_465 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_466 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_469 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_470 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_471 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_473 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_474 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_475 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_477 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_478 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_481 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_482 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_484 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_485 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_486 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_487 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_488 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_489 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_492 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_494 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_495 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_496 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_498 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_501 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_502 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_503 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_504 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_505 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_506 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_508 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_509 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_510 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_511 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_512 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_513 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_516 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_517 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_519 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_520 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_521 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_523 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_524 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_527 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_528 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_530 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_532 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_534 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_535 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_537 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_538 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_540 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_542 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_547 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_551 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_552 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_553 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_554 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_555 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_556 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_557 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_559 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_566 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_569 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_570 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_571 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_574 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_576 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_577 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_580 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_581 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_582 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_583 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_584 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_586 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_587 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_588 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_589 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_590 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_591 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_592 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_593 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_594 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_595 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_601 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_602 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_603 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_604 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_607 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_610 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_611 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_612 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_614 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_615 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_617 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_618 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_619 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_621 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_622 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_623 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_624 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_626 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_627 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_628 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_629 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_631 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_632 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_639 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_640 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_641 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_643 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_645 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_648 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_649 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_650 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_652 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_653 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_654 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_657 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_659 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_662 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_664 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_665 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_666 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_667 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_668 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_669 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_670 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_671 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_672 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_677 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_678 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_679 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_680 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_681 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_682 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_683 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_684 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_689 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_690 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_691 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_695 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_698 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_699 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_700 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_701 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_702 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_704 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_705 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_706 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_707 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_715 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_716 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_717 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_722 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_723 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_724 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_725 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_726 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_728 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_729 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_730 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_731 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_732 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_738 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_740 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_741 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_742 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_743 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_744 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_745 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_747 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_749 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_751 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_752 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_753 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_755 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_756 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_757 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_758 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_760 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_762 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_763 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_764 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_766 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_767 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_768 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_769 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_770 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_771 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_772 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_774 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_775 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_776 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_777 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_778 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_779 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_780 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_781 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_782 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_787 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_788 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_791 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_792 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_793 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_794 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_795 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_798 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_799 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_800 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_801 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_802 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_803 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_804 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_805 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_806 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_808 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_809 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_810 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_811 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_812 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_815 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_816 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_817 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_819 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_820 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_821 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_822 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_823 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_824 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_825 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_826 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_827 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_828 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_829 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_830 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_832 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_833 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_834 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_835 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_836 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_837 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_838 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_839 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_840 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_842 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_843 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_844 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_846 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_847 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_848 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_849 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_850 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_852 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_853 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_854 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_855 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_856 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_857 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_858 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_859 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_861 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_863 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_869 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_870 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_872 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_873 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_874 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_876 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_877 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_878 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_879 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_880 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_882 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_884 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_885 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_886 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_887 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_888 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_891 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_893 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_894 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_897 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_898 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_899 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_901 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_902 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_906 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_911 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_913 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_914 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_916 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_918 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_920 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_924 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_925 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_927 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_929 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_932 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_935 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_936 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_937 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_938 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_939 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_940 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_941 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_943 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_944 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_948 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_949 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_951 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_952 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_954 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_956 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_957 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_960 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_962 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_964 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_965 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_966 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_967 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_968 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_972 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_973 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_977 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_978 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_980 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_981 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_982 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_984 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_987 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_990 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_992 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_993 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_994 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_995 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_996 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_997 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_998 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1000 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1002 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1003 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1004 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1005 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1006 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1007 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1009 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1010 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1012 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1013 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1014 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1015 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1016 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1017 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1018 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1019 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1022 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1023 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1024 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1025 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1026 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1027 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1028 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1033 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1034 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1036 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1037 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1040 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1043 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1044 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1045 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1047 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1048 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1051 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1052 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1053 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1058 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1059 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1061 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1064 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1068 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1069 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1072 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1074 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1075 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1076 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1077 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1078 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1079 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1081 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1082 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1083 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1084 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1085 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1086 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1087 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1088 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1089 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1090 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1093 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1094 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1095 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1096 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1099 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1100 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1101 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1102 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1104 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1106 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1107 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1109 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1110 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1111 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1112 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1113 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1115 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1116 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1117 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1118 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1119 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1121 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1122 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1123 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1124 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1126 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1127 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1128 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1130 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1133 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1134 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1136 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1140 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1142 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1143 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1144 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1145 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1146 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1148 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1149 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1150 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1151 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1152 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1153 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1155 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1156 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1158 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1160 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1163 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1167 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1168 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1169 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1170 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1171 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1172 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1173 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1175 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1185 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1186 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1187 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1190 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1191 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1192 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1193 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1194 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1195 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1196 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1198 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1199 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1200 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1201 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1203 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1204 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1205 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1207 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1210 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1211 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1212 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1213 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1214 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1215 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1216 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1217 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1218 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1219 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1221 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1223 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1224 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1225 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1226 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1227 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1229 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1230 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1232 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1233 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1235 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1236 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1237 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1238 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1239 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1240 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1241 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1242 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1244 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1246 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1247 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1248 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1249 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1250 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1253 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1254 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1255 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1256 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1262 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1263 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1264 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1265 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1266 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1267 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1273 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1274 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1276 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1278 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1279 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1281 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1282 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1283 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1284 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1285 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1286 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1289 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1291 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1292 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1293 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1294 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1295 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1296 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1297 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1298 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1299 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1300 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1301 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1302 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1307 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1308 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1309 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1311 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1312 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1313 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1315 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1316 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1317 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1318 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1319 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1320 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1321 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1325 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1326 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1327 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1328 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1329 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1332 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1334 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1335 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1336 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1337 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1340 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1341 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1346 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1348 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1350 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1351 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1352 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1354 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1355 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1356 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1357 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1362 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1363 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1364 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1365 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1367 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1369 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1371 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1373 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1374 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1375 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1376 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1377 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1379 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1381 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1383 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1384 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1385 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1387 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1388 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1389 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1390 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1391 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1392 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1393 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1394 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1396 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1397 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1398 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1403 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1404 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1405 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1407 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1408 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1409 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1411 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1412 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1413 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1416 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1417 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1419 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1420 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1422 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1423 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1424 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1425 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1426 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1428 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1429 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1430 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1431 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1432 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1433 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1434 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1436 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1437 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1438 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1439 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1443 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1445 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1446 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1447 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1448 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1449 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1450 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1451 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1452 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1454 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1455 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1456 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1457 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1458 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1459 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1460 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1461 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1462 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1464 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1467 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1468 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1470 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1472 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1473 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1474 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1475 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1477 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1479 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1480 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1481 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1485 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1486 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1487 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1489 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1490 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1492 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1493 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1495 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1496 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1497 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1498 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1499 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1500 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1501 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1506 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1507 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1508 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1509 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1510 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1511 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1512 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1513 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1514 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1515 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1516 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1517 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1518 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1520 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1521 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1522 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1523 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1524 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1525 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1528 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1529 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1530 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1531 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1532 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1534 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1536 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1537 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1539 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1540 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1543 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1544 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1546 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1547 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1549 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1552 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1553 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1554 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1555 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1556 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1559 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1561 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1562 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1563 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1564 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1565 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1566 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1570 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1571 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1572 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1574 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1575 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1576 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1577 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1578 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1579 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1582 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1583 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1584 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1588 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1589 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1590 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1592 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1593 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1597 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1599 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1600 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1604 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1605 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1606 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1607 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1608 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1610 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1611 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1612 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1613 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1614 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1616 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1617 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1618 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1619 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1622 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1623 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1625 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1626 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1627 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1630 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1634 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1635 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1636 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1638 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1640 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1641 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1643 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1644 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1647 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1648 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1650 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1656 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1658 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1659 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1660 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1661 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1664 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1666 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1668 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1669 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1671 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1672 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1674 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1676 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1677 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1678 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1680 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1681 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1682 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1683 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1686 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1688 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1689 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1690 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1695 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1696 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1697 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1698 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1699 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1700 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1701 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1702 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1703 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1705 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1708 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1709 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1710 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1711 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1712 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1714 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1715 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1717 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1718 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1719 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1720 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1721 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1722 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1723 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1726 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1727 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1728 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1730 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1731 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1732 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1733 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1734 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1735 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1737 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1738 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1739 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1741 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1743 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1744 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1745 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1748 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1749 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1750 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1751 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1752 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1756 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1757 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1758 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1759 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1761 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1764 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1765 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1766 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1767 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1768 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1769 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1770 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1771 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1772 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1773 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1774 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1775 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1777 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1778 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1780 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1781 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1782 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1783 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1784 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1785 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1786 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1787 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1788 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1789 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1790 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1792 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1793 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1794 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1799 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1800 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1801 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1805 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1806 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1807 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1808 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1809 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1810 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1814 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1815 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1819 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1820 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1821 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1822 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1823 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1824 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1825 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1826 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1827 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1828 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1829 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1832 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1835 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1838 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1839 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1840 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1841 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1842 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1843 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1844 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1846 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1847 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1848 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1850 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1854 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1856 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1858 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1859 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1861 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1862 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1864 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1866 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1867 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1870 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1871 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1872 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1873 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1874 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1875 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1877 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1880 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1881 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1882 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1886 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1889 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1890 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1891 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1892 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1894 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1896 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1897 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1898 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1900 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1901 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1902 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1904 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1905 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1906 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1907 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1908 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1909 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1911 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1912 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1913 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1914 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1918 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1919 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1920 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1922 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1925 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1927 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1928 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1929 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1931 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1932 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1933 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1934 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1935 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1936 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1937 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1938 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1939 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1940 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1942 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1945 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1946 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1948 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1950 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1951 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1953 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1954 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1955 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1956 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1957 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1958 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1959 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1960 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1961 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1962 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1963 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1964 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1966 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1968 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1972 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1973 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1974 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1975 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1976 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1977 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1979 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1980 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1982 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1987 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1990 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1991 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1992 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1993 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1994 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1995 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1996 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1997 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_1998 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2000 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2003 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2004 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2005 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2007 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2008 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2009 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2011 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2012 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2013 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2017 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2019 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2020 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2021 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2022 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2026 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2027 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2028 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2029 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP8BWP7T_2031 DCAP8BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_4 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_5 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_7 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_8 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_9 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_10 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_15 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_17 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_18 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_20 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_22 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_23 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_24 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_25 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_26 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_27 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_28 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_29 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_30 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_31 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_32 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_34 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_36 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_37 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_38 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_39 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_40 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_41 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_42 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_43 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_45 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_46 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_47 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_48 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_50 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_51 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_53 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_54 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_55 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_56 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_60 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_62 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_63 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_64 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_65 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_66 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_68 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_71 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_73 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_76 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_77 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_78 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_79 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_80 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_81 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_82 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_83 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_85 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_86 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_88 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_89 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_92 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_93 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_94 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_95 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_96 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_97 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_98 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_102 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_104 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_106 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_107 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_108 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_109 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_111 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_112 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_114 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_115 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_117 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_119 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_120 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_121 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_127 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_128 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_131 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_132 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_133 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_138 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_139 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_142 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_143 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_144 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_145 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_146 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_147 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_149 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_150 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_151 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_152 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_153 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_154 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_155 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_160 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_161 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_162 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_164 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_166 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_167 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_168 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_169 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_171 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_172 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_173 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_174 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_176 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_179 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_181 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_182 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_183 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_185 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_188 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_192 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_193 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_194 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_195 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_196 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_197 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_198 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_199 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_200 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_201 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_202 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_204 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_205 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_206 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_208 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_209 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_210 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_212 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_215 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_216 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_217 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_218 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_219 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_221 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_222 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_224 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_225 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_227 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_229 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_231 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_232 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_233 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_235 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_236 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_237 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_240 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_241 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_242 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_243 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_246 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_247 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_250 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_251 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_252 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_253 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_255 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_256 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_257 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_258 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_260 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_261 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_263 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_264 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_266 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_267 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_271 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_272 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_273 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_274 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_275 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_276 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_277 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_278 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_280 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_281 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_285 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_286 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_287 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_288 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_289 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_290 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_291 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_293 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_297 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_299 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_300 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_301 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_302 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_303 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_304 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_305 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_306 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_307 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_308 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_309 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_312 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_313 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_314 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_318 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_319 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_323 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_325 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_326 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_328 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_329 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_330 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_331 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_334 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_335 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_337 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_338 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_339 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_340 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_343 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_344 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_346 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_347 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_348 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_354 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_356 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_357 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_358 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_359 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_360 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_364 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_365 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_366 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_368 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_369 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_370 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_372 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_373 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_374 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_375 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_376 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_379 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_380 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_381 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_382 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_383 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_384 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_386 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_387 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_388 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_394 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_395 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_399 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_400 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_401 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_404 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_405 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_406 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_409 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_410 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_411 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_414 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_416 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_419 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_423 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_425 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_426 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_427 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_428 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_429 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_430 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_433 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_439 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_441 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_443 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_444 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_445 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_446 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_447 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_448 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_449 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_450 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_453 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_454 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_456 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_457 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_462 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_463 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_464 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_467 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_468 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_470 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_471 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_472 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_473 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_478 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_479 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_480 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_484 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_485 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_487 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_488 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_491 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_492 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_494 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_496 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_497 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_498 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_499 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_500 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_501 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_502 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_503 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_504 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_506 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_507 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_508 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_510 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_511 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_512 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_514 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_516 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_518 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_519 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_521 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_522 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_523 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_525 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_527 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_528 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_531 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_533 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_535 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_539 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_540 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_542 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_543 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_544 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_545 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_548 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_550 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_551 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_552 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_553 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_555 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_556 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_557 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_560 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_562 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_563 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_566 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_567 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_568 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_569 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_572 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_573 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_575 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_576 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_578 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_579 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_580 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_583 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_584 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_585 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_586 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_588 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_589 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_591 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_592 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_594 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_595 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_599 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_601 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_604 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_606 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_607 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_608 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_611 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_612 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_614 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_615 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_619 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_620 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_622 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_623 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_624 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_625 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_627 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_629 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_634 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_635 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_638 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_640 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_641 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_642 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_643 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_646 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_647 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_648 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_649 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_650 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_651 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_652 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_653 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_654 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_655 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_656 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_657 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_658 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_659 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_660 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_661 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_662 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_665 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_669 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_670 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_672 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_674 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_675 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_677 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_678 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_679 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_680 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_681 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_684 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_685 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_686 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_687 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_688 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_689 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_690 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_691 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_694 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_698 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_699 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_701 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_702 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_703 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_704 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_705 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_706 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_707 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_708 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_709 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_710 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_712 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_713 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_714 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_715 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_717 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_721 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_725 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_726 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_728 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_730 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_731 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_732 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_733 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_735 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_736 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_737 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_738 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_739 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_741 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_743 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_745 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_746 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_749 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_750 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_753 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_754 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_756 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_757 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_758 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_759 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_760 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_763 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_764 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_765 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_766 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_767 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_768 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_771 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_772 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_773 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_775 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_776 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_777 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_778 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_779 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_782 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_783 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_785 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_786 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_787 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_788 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_792 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_793 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_794 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_795 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_796 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_797 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_798 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_799 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_800 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_801 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_805 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_807 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_813 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_814 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_815 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_817 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_819 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_820 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_821 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_822 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_827 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_828 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_830 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_831 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_832 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_833 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_834 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_835 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_837 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_838 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_839 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_840 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_841 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_843 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_844 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_845 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_847 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_848 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_849 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_850 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_852 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_854 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_856 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_857 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_858 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_859 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_860 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_861 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_862 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_864 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_865 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_866 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_867 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_868 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_869 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_870 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_872 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_873 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_874 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_875 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_876 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_880 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_881 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_882 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_884 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_885 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_887 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_889 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_890 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_891 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_893 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_894 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_895 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_898 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_899 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_900 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_901 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_902 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_903 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_905 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_906 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_907 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_912 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_913 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_914 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_916 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_919 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_920 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_921 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_922 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_923 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_927 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_929 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_930 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_931 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_932 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_933 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_934 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_936 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_937 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_938 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_940 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_941 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_942 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_943 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_944 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_945 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_947 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_949 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_950 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_952 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_953 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_954 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_955 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_956 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_957 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_958 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_959 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_961 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_963 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_964 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_965 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_966 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_967 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_968 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_969 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_971 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_972 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_974 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_975 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_976 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_977 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_979 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_980 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_981 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_983 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_984 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_985 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_986 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_987 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_989 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_990 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_991 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_992 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_993 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_998 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_999 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1000 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1001 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1002 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1003 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1005 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1007 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1010 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1016 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1017 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1018 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1020 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1021 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1022 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1024 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1026 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1027 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1028 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1029 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1030 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1033 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1037 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1039 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1040 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1041 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1042 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1045 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1046 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1047 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1048 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1051 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1052 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1053 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1054 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1056 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1059 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1061 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1062 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1065 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1069 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1072 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1073 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1074 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1075 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1076 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1079 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1081 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1083 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1084 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1086 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1087 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1088 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1090 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1091 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1092 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1093 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1094 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1095 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1096 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1099 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1102 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1106 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1107 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1108 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1109 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1113 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1115 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1116 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1117 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1118 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1119 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1123 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1124 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1125 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1126 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1127 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1128 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1129 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1131 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1135 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1136 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1138 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1139 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1140 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1141 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1144 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1145 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1146 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1147 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1149 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1150 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1151 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1152 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1153 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1156 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1157 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1159 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1162 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1163 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1164 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1165 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1169 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1170 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1171 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1172 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1174 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1175 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1176 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1177 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1178 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1179 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1180 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1189 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1190 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1191 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1193 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1194 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1195 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1196 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1198 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1199 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1200 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1201 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1202 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1203 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1204 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1205 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1206 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1207 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1208 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1210 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1214 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1215 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1218 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1220 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1224 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1225 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1226 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1227 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1228 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1229 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1230 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1231 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1232 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1234 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1238 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1242 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1243 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1244 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1246 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1247 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1249 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1250 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1252 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1253 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1254 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1255 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1256 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1257 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1258 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1259 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1260 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1262 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1263 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1267 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1270 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1272 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1276 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1278 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1280 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1281 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1282 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1285 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1288 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1289 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1290 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1291 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1293 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1294 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1295 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1296 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1298 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1299 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1300 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1301 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1302 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1303 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1305 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1307 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1311 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1312 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1315 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1318 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1319 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1320 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1321 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1325 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1326 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1327 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1328 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1329 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1332 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1334 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1337 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1338 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1339 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1340 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1341 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1342 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1343 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1345 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1346 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1347 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1354 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1355 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1356 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1357 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1358 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1359 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1360 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1361 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1362 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1363 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1364 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1366 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1367 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1369 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1370 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1371 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1372 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1373 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1374 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1376 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1378 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1380 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1381 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1382 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1383 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1386 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1388 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1390 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1392 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1394 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1396 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1398 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1399 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1400 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1401 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1403 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1404 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1406 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1408 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1410 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1412 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1413 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1414 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1416 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1419 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1421 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1422 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1424 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1425 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1426 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1429 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1431 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1432 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1435 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1437 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1438 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1440 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1441 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1443 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1448 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1450 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1451 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1452 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1454 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1455 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1457 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1458 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1460 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1461 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1462 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1465 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1468 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1469 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1470 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1471 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1473 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1474 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1475 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1476 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1477 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1478 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1479 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1480 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1482 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1483 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1485 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1489 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1491 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1492 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1493 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1494 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1497 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1498 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1499 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1507 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1508 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1509 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1510 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1511 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1512 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1513 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1514 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1518 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1519 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1520 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1521 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1522 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1523 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1524 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1525 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1526 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1527 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1528 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1531 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1534 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1535 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1537 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1539 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1540 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1542 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1543 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1544 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1546 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1548 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1551 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1552 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1553 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1554 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1555 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1562 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1564 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1565 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1566 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1567 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1568 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1571 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1572 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1573 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1574 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1578 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1580 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1581 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1583 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1584 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1585 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1586 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1587 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1589 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1592 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1593 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1594 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1595 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1598 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1603 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1606 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1607 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1609 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1610 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1615 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1616 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1617 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1618 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1619 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1620 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1622 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1623 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1624 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1625 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1626 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1627 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1629 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1630 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1632 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1633 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1639 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1640 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1641 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1642 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1644 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1645 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1646 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1647 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1648 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1650 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1651 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1652 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1653 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1655 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1656 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1657 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1658 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1659 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1660 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1661 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1666 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1667 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1668 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1669 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1670 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1674 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1675 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1676 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1677 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1678 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1679 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1680 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1681 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1683 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1684 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1689 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1690 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1691 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1692 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1694 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1698 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1699 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1703 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1704 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1706 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1707 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1712 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1713 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1716 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1717 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1718 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1719 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1720 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1721 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1722 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1723 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1724 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1725 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1726 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1728 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1729 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1730 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1732 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1736 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1737 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1738 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1739 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1741 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1743 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1744 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1745 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1746 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1747 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1748 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1749 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1751 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1752 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1753 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1756 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1757 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1758 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1759 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1760 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1762 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1763 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1764 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1765 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1766 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1767 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1768 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1769 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1771 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1772 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1773 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1774 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1775 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1776 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1777 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1779 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1781 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1782 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1784 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1785 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1787 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1789 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1790 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1792 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1795 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1799 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1800 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1802 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1803 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1805 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1806 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1807 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1808 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1810 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1812 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1813 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1814 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1815 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1816 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1817 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1818 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1819 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1821 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1828 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1830 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1831 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1834 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1835 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1836 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1837 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1838 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1840 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1841 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1843 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1844 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1847 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1851 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1853 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1858 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1859 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1861 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1862 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1863 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1864 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1865 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1867 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1870 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1873 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1876 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1877 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1878 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1879 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1880 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1881 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1882 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1883 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1885 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1887 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1888 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1889 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1890 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1891 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1897 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1899 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1900 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1901 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1903 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1904 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1907 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1908 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1909 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1910 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1912 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1913 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1914 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1915 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1916 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1917 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1923 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1925 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1926 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1929 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1930 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1935 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1936 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1937 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1939 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1940 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1941 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1942 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1943 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1944 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1947 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1952 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1956 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1960 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1963 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1964 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1965 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1966 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1967 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1970 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1973 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1974 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1976 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1977 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1978 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1981 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1982 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1985 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1989 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1990 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1997 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_1999 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2000 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2001 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2003 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2004 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2005 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2006 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2007 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2008 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2009 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2010 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2012 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2014 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2015 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2017 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2018 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2019 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2020 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2023 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2024 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2025 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2026 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2027 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2029 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2030 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2031 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2033 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2034 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2036 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2038 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2039 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2040 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2041 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2043 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2045 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2048 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2057 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2058 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2061 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2062 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2063 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2064 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2065 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2066 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2067 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2070 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2074 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2075 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2076 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2077 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2078 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2079 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2080 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2082 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2083 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2084 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2086 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2087 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2088 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2089 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2090 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2092 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2093 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2094 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2096 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2097 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2099 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2102 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2109 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2111 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2112 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2113 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2114 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2116 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2117 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2119 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2120 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2121 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2123 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2126 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2127 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2132 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2134 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2135 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2136 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2137 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2138 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2139 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2140 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2141 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2144 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2145 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2146 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2148 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2150 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2153 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2154 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2157 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2158 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2159 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2160 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2161 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2164 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2165 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2167 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2169 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2170 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2171 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2172 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2173 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2176 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2178 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2180 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2181 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2182 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2183 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2184 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2185 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2187 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2188 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2189 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2190 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2191 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2199 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2200 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2202 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2203 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2205 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2206 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2208 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2209 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2210 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2212 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2217 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2218 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2219 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2220 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2222 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2223 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2224 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2225 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2227 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2228 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2229 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2230 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2231 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2241 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2242 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2243 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2244 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2245 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2248 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2251 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2252 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2254 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2255 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2256 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2257 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2259 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2260 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2261 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2265 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2267 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2268 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2269 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2270 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2271 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2272 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2273 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2274 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2276 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2277 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2278 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2279 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2280 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2285 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2287 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2288 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2289 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2290 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2291 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2292 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2293 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2294 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2295 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2296 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2297 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2298 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2304 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2305 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2307 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2308 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2309 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2311 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2312 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2313 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2314 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2315 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2316 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2318 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2319 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2321 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2322 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2323 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2324 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2325 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2331 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2332 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2333 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2334 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2336 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2338 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2339 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2341 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2343 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2344 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2345 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2346 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2347 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2349 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2356 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2358 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2359 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2362 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2363 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2364 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2365 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2366 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2367 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2369 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2370 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2372 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2373 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2374 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2378 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2382 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2383 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2386 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2388 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2389 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2390 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2391 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2392 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2393 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2394 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2395 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2396 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2397 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2398 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2399 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2400 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2404 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2405 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2406 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2407 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2408 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2409 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2410 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2411 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2412 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2413 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2414 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2415 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2418 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2419 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2420 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2425 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2426 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2434 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2435 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2436 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2437 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2442 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2445 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2446 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2447 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2448 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2453 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2455 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2456 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2459 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2460 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2461 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2462 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2463 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2464 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2465 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2467 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2468 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2470 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2471 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2472 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2475 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2479 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2481 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2486 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2490 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2491 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2493 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2494 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2496 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2497 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2498 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2500 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2501 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2502 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2509 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2510 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2513 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2514 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2517 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2518 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2521 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2523 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2524 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2525 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2527 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2528 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2529 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2533 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2536 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2537 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2540 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2541 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2542 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2543 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2544 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2545 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2546 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2547 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2551 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2552 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2553 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2559 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2560 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2561 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2564 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2565 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2567 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2568 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2569 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2571 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2574 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2575 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2576 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2579 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2580 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2581 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2586 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2587 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2589 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2590 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2593 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2594 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2595 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2596 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2597 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2598 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2599 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2600 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2601 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2602 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2604 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2605 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2607 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2610 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2611 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2613 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2615 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2616 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2621 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2622 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2623 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2625 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2626 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2627 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2628 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2629 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2630 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2631 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2632 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2637 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2638 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2643 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2644 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2645 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2646 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2650 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2651 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2653 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2657 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2658 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2659 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2660 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2661 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2662 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2665 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2666 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2667 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2669 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2671 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2674 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2675 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2678 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2680 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2681 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2682 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2683 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2687 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2688 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2689 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2690 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2691 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2692 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2693 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2694 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2695 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2696 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2697 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2698 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2702 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2703 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2704 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2706 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2712 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2713 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2714 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2715 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2716 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2717 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2718 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2719 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2720 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2721 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2722 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2724 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2725 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2726 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2728 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2729 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2730 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2732 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2735 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2736 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2737 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2738 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2739 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2740 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2741 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2743 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2748 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2750 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2754 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2755 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2756 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2757 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2758 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2759 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2760 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2761 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2762 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2763 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2764 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2767 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2768 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2769 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2773 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2780 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2782 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2783 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2784 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2785 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2786 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2787 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2789 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2790 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2791 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2798 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2799 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2800 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2803 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2805 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2806 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2807 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2810 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2811 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2812 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2813 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2815 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2816 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2817 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2818 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2820 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2822 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2824 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2827 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2828 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2830 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2831 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2834 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2837 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2839 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2840 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2841 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2842 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2843 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2844 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2845 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2851 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2852 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2857 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2858 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2859 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2860 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2861 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2863 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2866 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2867 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2868 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2869 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2876 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2878 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2879 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2881 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2882 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2883 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2884 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2885 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2886 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2887 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2888 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2889 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2890 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2891 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2892 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2894 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2898 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2901 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2902 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2904 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2907 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2910 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2911 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2912 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2913 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2914 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2915 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2917 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2918 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2919 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2920 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2922 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2923 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2924 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2925 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2926 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2933 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2934 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2935 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2936 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2937 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2938 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2940 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2941 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2942 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2943 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2944 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2945 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2946 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2947 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2948 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2949 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2951 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2952 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2953 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2955 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2956 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2957 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2960 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2961 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2964 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2966 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2967 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2968 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2969 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2970 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2971 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2973 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2974 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2975 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2976 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2977 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2978 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2979 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2983 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2984 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2986 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2987 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2990 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2991 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2992 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2993 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2994 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2995 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2996 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2997 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2998 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_2999 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3000 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3001 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3005 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3007 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3008 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3012 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3014 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3015 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3016 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3017 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3018 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3019 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3020 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3021 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3022 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3023 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3025 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3026 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3029 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3030 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3031 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3032 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3033 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3035 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3036 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3037 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3038 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3039 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3040 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3041 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3042 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3044 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3048 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3049 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3050 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3051 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3052 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3053 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3054 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3055 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3056 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3058 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3060 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3061 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3062 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3063 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3064 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3065 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3066 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3067 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3068 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAP4BWP7T_3070 DCAP4BWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_2 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_4 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_5 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_6 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_7 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_8 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_9 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_10 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_12 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_15 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_16 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_17 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_19 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_20 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_21 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_22 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_23 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_24 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_25 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_26 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_31 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_32 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_34 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_36 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_37 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_38 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_39 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_40 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_41 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_42 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_43 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_45 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_48 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_49 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_51 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_52 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_53 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_54 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_55 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_56 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_57 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_59 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_60 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_64 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_65 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_66 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_67 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_68 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_69 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_71 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_72 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_74 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_75 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_76 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_78 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_79 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_80 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_81 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_82 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_84 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_85 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_86 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_89 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_90 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_91 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_92 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_93 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_94 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_96 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_98 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_99 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_102 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_103 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_108 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_109 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_110 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_111 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_112 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_113 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_115 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_116 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_119 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_120 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_121 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_123 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_125 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_127 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_129 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_130 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_131 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_132 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_135 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_139 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_140 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_144 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_145 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_146 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_149 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_151 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_152 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_157 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_158 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_159 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_160 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_162 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_166 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_167 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_168 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_169 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_170 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_171 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_172 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_173 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_174 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_175 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_176 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_177 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_180 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_184 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_185 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_186 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_187 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_189 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_192 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_193 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_194 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_195 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_196 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_197 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_198 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_199 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_204 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_205 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_208 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_209 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_210 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_211 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_215 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_219 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_220 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_222 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_223 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_225 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_226 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_229 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_232 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_236 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_237 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_241 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_244 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_245 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_248 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_249 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_251 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_252 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_253 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_255 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_257 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_258 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_259 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_265 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_266 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_267 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_270 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_272 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_273 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_274 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_275 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_277 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_278 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_281 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_283 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_285 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_290 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_291 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_292 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_295 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_296 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_297 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_299 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_300 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_301 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_302 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_304 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_306 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_309 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_310 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_311 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_312 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_313 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_315 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_316 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_318 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_320 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_321 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_323 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_324 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_325 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_327 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_329 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_330 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_332 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_335 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_336 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_337 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_338 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_339 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_340 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_341 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_345 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_346 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_347 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_348 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_349 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_351 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_352 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_354 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_355 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_356 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_359 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_360 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_362 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_365 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_367 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_368 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_369 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_371 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_372 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_373 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_374 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_375 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_376 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_379 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_380 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_382 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_383 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_384 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_385 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_386 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_387 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_388 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_389 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_390 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_394 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_395 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_396 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_397 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_399 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_400 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_401 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_403 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_405 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_406 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_407 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_408 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_409 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_410 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_411 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_412 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_414 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_416 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_417 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_418 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_420 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_422 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_423 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_426 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_427 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_430 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_431 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_432 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_435 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_437 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_440 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_442 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_444 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_446 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_447 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_448 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_449 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_450 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_451 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_453 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_454 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_455 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_458 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_461 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_462 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_468 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_469 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_470 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_471 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_473 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_474 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_476 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_477 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_482 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_483 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_484 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_485 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_486 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_487 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_489 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_490 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_491 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_492 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_493 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_495 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_496 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_498 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_502 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_503 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_504 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_505 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_506 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_507 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_510 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_519 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_520 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_521 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_523 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_524 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_525 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_526 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_528 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_529 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_530 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_532 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_533 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_535 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_537 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_538 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_539 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_540 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_541 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_542 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_543 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_545 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_546 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_547 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_548 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_549 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_551 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_552 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_553 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_555 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_556 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_558 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_559 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_560 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_562 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_564 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_565 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_566 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_569 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_570 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_572 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_573 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_574 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_575 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_577 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_578 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_579 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_580 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_582 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_583 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_587 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_588 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_590 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_594 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_596 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_599 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_600 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_601 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_603 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_604 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_607 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_608 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_610 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_611 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_612 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_613 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_614 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_616 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_617 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_619 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_622 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_623 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_624 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_627 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_628 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_630 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_633 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_635 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_636 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_639 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_640 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_644 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_645 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_646 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_648 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_650 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_651 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_652 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_653 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_656 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_657 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_659 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_660 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_661 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_662 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_665 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_666 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_668 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_670 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_671 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_675 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_676 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_677 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_678 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_683 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_684 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_686 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_687 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_688 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_690 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_692 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_694 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_695 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_696 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_699 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_700 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_701 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_703 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_704 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_705 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_707 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_709 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_714 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_715 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_716 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_717 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_718 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_719 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_720 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_721 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_725 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_726 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_727 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_730 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_731 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_732 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_733 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_734 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_735 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_738 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_740 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_741 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_742 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_743 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_744 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_745 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_746 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_747 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_748 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_755 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_756 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_757 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_759 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_761 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_762 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_765 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_767 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_769 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_770 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_772 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_773 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_774 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_775 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_776 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_777 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_778 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_784 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_786 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_787 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_788 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_789 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_796 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_797 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_798 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_799 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_800 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_801 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_803 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_804 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_805 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_807 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_808 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_810 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_811 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_815 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_820 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_821 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_822 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_825 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_829 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_830 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_831 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_832 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_835 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_839 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_842 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_843 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_845 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_849 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_850 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_851 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_854 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_855 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_858 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_860 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_865 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_867 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_869 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_870 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_874 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_875 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_876 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_882 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_884 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_888 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_889 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_890 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_891 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_892 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_894 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_895 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_896 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_898 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_899 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_900 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_902 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_903 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_907 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_908 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_909 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_912 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_913 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_914 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_916 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_919 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_920 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_921 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_923 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_927 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_928 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_929 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_930 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_932 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_933 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_934 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_936 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_938 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_939 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_941 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_943 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_944 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_946 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_947 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_949 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_950 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_951 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_952 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_953 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_954 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_955 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_956 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_957 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_958 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_959 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_960 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_961 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_962 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_965 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_967 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_968 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_969 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_970 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_971 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_972 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_974 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_975 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_976 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_977 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_978 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_979 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_984 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_985 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_988 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_989 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_991 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_992 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_993 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_997 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_998 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1002 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1003 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1004 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1006 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1007 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1010 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1011 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1016 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1017 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1018 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1019 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1020 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1023 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1024 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1025 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1027 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1028 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1029 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1032 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1033 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1035 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1036 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1043 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1044 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1046 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1047 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1048 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1049 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1052 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1054 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1055 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1058 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1059 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1061 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1062 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1063 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1064 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1065 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1067 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1068 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1069 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1074 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1075 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1078 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1079 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1081 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1083 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1084 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1085 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1089 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1093 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1094 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1095 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1096 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1097 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1100 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1102 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1105 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1106 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1107 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1109 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1110 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1113 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1117 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1118 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1121 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1122 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1127 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1128 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1129 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1131 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1132 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1133 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1135 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1136 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1138 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1140 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1141 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1142 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1143 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1147 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1148 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1150 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1151 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1152 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1154 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1156 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1157 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1158 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1163 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1164 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1168 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1169 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1170 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1171 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1175 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1176 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1178 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1179 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1181 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1182 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1183 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1184 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1185 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1188 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1191 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1195 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1196 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1197 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1199 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1200 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1201 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1206 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1208 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1211 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1214 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1215 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1216 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1221 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1222 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1223 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1224 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1225 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1226 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1229 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1230 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1233 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1234 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1235 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1238 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1240 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1241 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1244 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1246 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1247 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1250 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1251 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1252 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1254 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1255 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1257 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1260 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1261 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1263 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1264 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1265 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1266 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1267 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1268 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1269 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1270 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1271 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1272 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1273 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1275 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1276 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1277 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1278 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1280 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1281 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1282 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1283 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1284 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1285 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1286 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1287 DCAPBWP7T $PINS VSS=VSS VDD=VDD
Xxofiller_DCAPBWP7T_1288 DCAPBWP7T $PINS VSS=VSS VDD=VDD
.ENDS
.GLOBAL VDD
.GLOBAL VSS
